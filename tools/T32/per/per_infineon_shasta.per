; @file:      analog.per
; Chip name:  SHASTA
; Module:     analog
; 
; Generated by the pmm metagen library.
;
; ===================================================================
; Copyright (C) 2018 Infineon Technologies AG
; All rights reserved.
; ===================================================================
;
; ===================================================================
; This document contains proprietary information. Passing on and
; copying of this document, and communication of its contents is not
; permitted without prior written authorisation.
; ===================================================================

; This file is automatically generated. Do not edit!


config 32. 8.
width 20.

tree "Block - analog"
; -------------------------------------------------------------------
; Begin Block - analog
; -------------------------------------------------------------------
base D:0x70000400

tree "analog"
; ----------------------- VS_STEP member of analog -----------------------

  group 0x0000++0x0003
    line.long 0x000 "VS_STEP, VS0 (VSEN) tracking loop step size when automatic step size disabled."
    textline "                   "
    hexmask.long.byte 0x0 0.--2. 0x1 0x0 " vs0_step                  ,VS0 (VSEN) tracking loop step size when automatic step size disabled."
    textline "                   "
    hexmask.long.byte 0x0 3.--3. 0x1 0x0 " vs0_step_en               ,VS0 (VSEN) tracking loop step size control. "
    textline "                   "
    hexmask.long.byte 0x0 4.--6. 0x1 0x0 " vs1_step                  ,VS1 (VRSEN) tracking loop step size when automatic step size disabled."
    textline "                   "
    hexmask.long.byte 0x0 7.--7. 0x1 0x0 " vs1_step_en               ,VS1 (VRSEN) tracking loop step size control. "
    textline "                   "
    hexmask.long.byte 0x0 8.--10. 0x1 0x0 " vs2_step                  ,VS2 (BVSEN_BVRSEN) tracking loop step size when automatic step size disabled."
    textline "                   "
    hexmask.long.byte 0x0 11.--11. 0x1 0x0 " vs2_step_en               ,VS2 (BVSEN_BVRSEN) tracking loop step size control. "
    textline "                   "
    hexmask.long.byte 0x0 12.--13. 0x1 0x0 " isen1_gain_mode           ,ISEN1 (ISEN) gain mode select.  Defines LSB weight of ISEN1 ADC.  Also defines expected  reference voltage level on IREF1 (IREF). "
    textline "                   "
    hexmask.long.byte 0x0 14.--15. 0x1 0x0 " isen2_gain_mode           ,ISEN2 (BISEN) gain mode select.  Defines LSB weight of ISEN2 ADC.  Also defines expected  reference voltage level on IREF2 (BIREF). "

; --------------------- VS0_OSP_IN member of analog ---------------------

  group 0x0004++0x0003
    line.long 0x000 "VS0_OSP_IN, VREF open sense protection current enable.  When enabled, a 100uA current is sourced to the VREF pin.  This can be used to detect higher that expected voltage rise on the VREF pin prior to startup indicative of a higher than expected impedance at the VREF pin. "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " vs0_osp_cur_n_en          ,VREF open sense protection current enable.  When enabled, a 100uA current is sourced to the VREF pin.  This can be used to detect higher that expected voltage rise on the VREF pin prior to startup indicative of a higher than expected impedance at the VREF pin. "

; --------------------- VS0_OSP_IP member of analog ---------------------

  group 0x0008++0x0003
    line.long 0x000 "VS0_OSP_IP, VSEN open sense protection current enable.  When enabled, a 100uA current is sourced to the VSEN pin.  This can be used to detect higher that expected voltage rise on the VSEN pin prior to startup indicative of a higher than expected impedance at the VSEN pin. "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " vs0_osp_cur_p_en          ,VSEN open sense protection current enable.  When enabled, a 100uA current is sourced to the VSEN pin.  This can be used to detect higher that expected voltage rise on the VSEN pin prior to startup indicative of a higher than expected impedance at the VSEN pin. "

; --------------------- VS1_OSP_IN member of analog ---------------------

  group 0x000C++0x0003
    line.long 0x000 "VS1_OSP_IN, VRREF open sense protection current enable.  When enabled, a 100uA current is sourced to the VRREF pin.  This can be used to detect higher that expected voltage rise on the VRREF pin prior to startup indicative of a higher than expected impedance at the VRREF pin. "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " vs1_osp_cur_n_en          ,VRREF open sense protection current enable.  When enabled, a 100uA current is sourced to the VRREF pin.  This can be used to detect higher that expected voltage rise on the VRREF pin prior to startup indicative of a higher than expected impedance at the VRREF pin. "

; --------------------- VS1_OSP_IP member of analog ---------------------

  group 0x0010++0x0003
    line.long 0x000 "VS1_OSP_IP, VRSEN open sense protection current enable.  When enabled, a 100uA current is sourced to the VRSEN pin.  This can be used to detect higher that expected voltage rise on the VRSEN pin prior to startup indicative of a higher than expected impedance at the VRSEN pin. "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " vs1_osp_cur_p_en          ,VRSEN open sense protection current enable.  When enabled, a 100uA current is sourced to the VRSEN pin.  This can be used to detect higher that expected voltage rise on the VRSEN pin prior to startup indicative of a higher than expected impedance at the VRSEN pin. "

; --------------------- VS2_OSP_IN member of analog ---------------------

  group 0x0014++0x0003
    line.long 0x000 "VS2_OSP_IN, BVREF_BVRREF open sense protection current enable.  When enabled, a 100uA current is sourced to the BVREF_BVRREF pin.  This can be used to detect higher that expected voltage rise on the BVREF_BVRREF pin prior to startup indicative of a higher than expected impedance at the BVREF_BVRREF pin. "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " vs2_osp_cur_n_en          ,BVREF_BVRREF open sense protection current enable.  When enabled, a 100uA current is sourced to the BVREF_BVRREF pin.  This can be used to detect higher that expected voltage rise on the BVREF_BVRREF pin prior to startup indicative of a higher than expected impedance at the BVREF_BVRREF pin. "

; --------------------- VS2_OSP_IP member of analog ---------------------

  group 0x0018++0x0003
    line.long 0x000 "VS2_OSP_IP, BVSEN_BVRSEN open sense protection current enable.  When enabled, a 100uA current is sourced to the BVSEN_BVRSEN pin.  This can be used to detect higher that expected voltage rise on the BVSEN_BVRSEN pin prior to startup indicative of a higher than expected impedance at the BVSEN_BVRSEN pin. "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " vs2_osp_cur_p_en          ,BVSEN_BVRSEN open sense protection current enable.  When enabled, a 100uA current is sourced to the BVSEN_BVRSEN pin.  This can be used to detect higher that expected voltage rise on the BVSEN_BVRSEN pin prior to startup indicative of a higher than expected impedance at the BVSEN_BVRSEN pin. "

; ------------------- VS_INTEG_RESET member of analog -------------------

  group 0x001C++0x0003
    line.long 0x000 "VS_INTEG_RESET, Voltage Sense integrator min/max detect reset.  Bit corresponding to targeted voltage sense must be set high to reset the min/max detector then set low to reenable the detector. "
    textline "                   "
    hexmask.long.byte 0x0 0.--2. 0x1 0x0 " vs_integ_reset            ,Voltage Sense integrator min/max detect reset.  Bit corresponding to targeted voltage sense must be set high to reset the min/max detector then set low to reenable the detector. "

tree.end

; -------------------------------------------------------------------
; End Block - analog
; -------------------------------------------------------------------
tree.end
; @file:      cgu.per
; Chip name:  SHASTA
; Module:     cgu
; 
; Generated by the pmm metagen library.
;
; ===================================================================
; Copyright (C) 2018 Infineon Technologies AG
; All rights reserved.
; ===================================================================
;
; ===================================================================
; This document contains proprietary information. Passing on and
; copying of this document, and communication of its contents is not
; permitted without prior written authorisation.
; ===================================================================

; This file is automatically generated. Do not edit!


config 32. 8.
width 20.

tree "Block - cgu"
; -------------------------------------------------------------------
; Begin Block - cgu
; -------------------------------------------------------------------
base D:0x40002000

tree "cgu"
; ------------------- ALPHA_CLK_DIV_CTRL member of cgu -------------------

  group 0x0000++0x0003
    line.long 0x000 "ALPHA_CLK_DIV_CTRL, Alpha Clock Divider Control Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--4. 0x1 0x0 " alpha_clk_div             ,This reset value generates a default clock frequency of    hosc_clk/4 for clk_alpha"

; -------------------- CPU_CLK_DIV_CTRL member of cgu --------------------

  group 0x0004++0x0003
    line.long 0x000 "CPU_CLK_DIV_CTRL, CPU Clock Divider Control Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--4. 0x1 0x0 " cpuclk_div                ,This reset value set the cpu_clk equal to alpha_clk (Divisor    value is 1, when configuration = 0)."

; -------------------- KRN_CLK_DIV_CTRL member of cgu --------------------

  group 0x0008++0x0003
    line.long 0x000 "KRN_CLK_DIV_CTRL, Kernel Clocks Divider Control Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--4. 0x1 0x0 " dtimer1_kernel_clk_div    ,This reset value set the cpu_clk equal to alpha_clk (Divisor    value is 1, when configuration = 0)."
    textline "                   "
    hexmask.long.byte 0x0 5.--9. 0x1 0x0 " dtimer2_kernel_clk_div    ,This reset value set the cpu_clk equal to alpha_clk (Divisor    value is 1, when configuration = 0)."
    textline "                   "
    hexmask.long.byte 0x0 10.--14. 0x1 0x0 " dtimer3_kernel_clk_div    ,This reset value set the cpu_clk equal to alpha_clk (Divisor    value is 1, when configuration = 0)."
    textline "                   "
    hexmask.long.byte 0x0 15.--19. 0x1 0x0 " wdt_kernel_clk_div        ,This reset value set the cpu_clk equal to alpha_clk (Divisor    value is 1, when configuration = 0)."
    textline "                   "
    hexmask.long.byte 0x0 20.--24. 0x1 0x0 " pmbus_kernel_clk_div      ,This reset value set the cpu_clk equal to alpha_clk (Divisor    value is 1, when configuration = 0)."
    textline "                   "
    hexmask.long.byte 0x0 25.--29. 0x1 0x0 " otp_kernel_clk_div        ,This reset value set the cpu_clk equal to alpha_clk (Divisor    value is 1, when configuration = 0)."

; ---------------------- CLKOUT_CTRL member of cgu ----------------------

  group 0x000C++0x0003
    line.long 0x000 "CLKOUT_CTRL, Clockout Control Register"
    textline "                   "
    bitfld.long 0x0 0.--3. " clkout_mux                ,Clock out (clkout_mux) selection." "S0 (0),S1 (1),S2 (2),S3 (3),S4 (4),S5 (5),S6 (6),S7 (7),S8 (8),S9 (9),S10 (a),S11 (b),S12 (c),S13 (d),S14 (e),S15 (f)"
    textline "                   "
    hexmask.long.byte 0x0 4.--7. 0x1 0x0 " clkout_mux_div            ,clkout = clkout_mux/(2^div)"
    textline "                   "
    hexmask.long.byte 0x0 8.--8. 0x1 0x0 " clkout_g                  ,1: Clockout is live"

; ---------------------- CLK_EN_CTRL member of cgu ----------------------

  group 0x0010++0x0003
    line.long 0x000 "CLK_EN_CTRL, Clock Enable Control Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " hosc_clk_g                ,1: Clock ‘ CrossRefz ’    is live"
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " rom_clk_g                 ,1: Clock ‘ CrossRefz ’    is live"
    textline "                   "
    hexmask.long.byte 0x0 2.--2. 0x1 0x0 " ram1_clk_g                ,1: Clock ‘ CrossRefz ’    is live"
    textline "                   "
    hexmask.long.byte 0x0 3.--3. 0x1 0x0 " ram2_clk_g                ,1: Clock ‘ CrossRefz ’    is live"
    textline "                   "
    hexmask.long.byte 0x0 4.--4. 0x1 0x0 " amba_clk_g                ,1: Clock ‘ CrossRefz ’    is live"
    textline "                   "
    hexmask.long.byte 0x0 5.--5. 0x1 0x0 " dma_clk_g                 ,1: Clock ‘ CrossRefz ’    is live"
    textline "                   "
    hexmask.long.byte 0x0 6.--6. 0x1 0x0 " cnfg_otp1_w_clk_g         ,1: Clock ‘ CrossRefz ’    and  CrossRefz  are live"
    textline "                   "
    hexmask.long.byte 0x0 10.--10. 0x1 0x0 " cnfg_dma_clk_g            ,1: Clock ‘ CrossRefz ’    and  CrossRefz  are live"
    textline "                   "
    hexmask.long.byte 0x0 11.--11. 0x1 0x0 " bif_reg_clk_g             ,1: Clock ‘ CrossRefz ’    is live"
    textline "                   "
    hexmask.long.byte 0x0 12.--12. 0x1 0x0 " bif_per_svid_clk_g        ,1: Clock ‘ CrossRefz ’    and  CrossRefz  are live"
    textline "                   "
    hexmask.long.byte 0x0 13.--13. 0x1 0x0 " bif_per_pmbus_clk_g       ,1: Clock ‘ CrossRefz ’    and  CrossRefz  are live"
    textline "                   "
    hexmask.long.byte 0x0 14.--14. 0x1 0x0 " bif_per_ssp_clk_g         ,1: Clock ‘ CrossRefz ’    and  CrossRefz  are live"
    textline "                   "
    hexmask.long.byte 0x0 15.--15. 0x1 0x0 " bif_per_i2c_clk_g         ,1: Clock ‘ CrossRefz ’    and  CrossRefz  are live"
    textline "                   "
    hexmask.long.byte 0x0 16.--16. 0x1 0x0 " bif_per_uart_clk_g        ,1: Clock ‘ CrossRefz ’    and  CrossRefz  are live"
    textline "                   "
    hexmask.long.byte 0x0 17.--17. 0x1 0x0 " dtimer1_clk_g             ,1: Clock ‘ CrossRefz ’    and  CrossRefz  are live"
    textline "                   "
    hexmask.long.byte 0x0 18.--18. 0x1 0x0 " dtimer2_clk_g             ,1: Clock ‘ CrossRefz ’    and  CrossRefz  are live"
    textline "                   "
    hexmask.long.byte 0x0 19.--19. 0x1 0x0 " dtimer3_clk_g             ,1: Clock ‘ CrossRefz ’    and  CrossRefz  are live"
    textline "                   "
    hexmask.long.byte 0x0 20.--20. 0x1 0x0 " wdt_clk_g                 ,1: Clock ‘ CrossRefz ’    and  CrossRefz  are live"
    textline "                   "
    hexmask.long.byte 0x0 21.--21. 0x1 0x0 " gpio0_clk_g               ,1: Clock ‘ CrossRefz ’    and  CrossRefz  are live"
    textline "                   "
    hexmask.long.byte 0x0 22.--22. 0x1 0x0 " gpio1_clk_g               ,1: Clock ‘ CrossRefz ’    and  CrossRefz  are live"
    textline "                   "
    hexmask.long.byte 0x0 23.--23. 0x1 0x0 " dtimer1_kernel_clk_g      ,1: Clock ‘ CrossRefz ’    is live"
    textline "                   "
    hexmask.long.byte 0x0 24.--24. 0x1 0x0 " dtimer2_kernel_clk_g      ,1: Clock ‘ CrossRefz ’    is live"
    textline "                   "
    hexmask.long.byte 0x0 25.--25. 0x1 0x0 " dtimer3_kernel_clk_g      ,1: Clock ‘ CrossRefz ’    is live"
    textline "                   "
    hexmask.long.byte 0x0 26.--26. 0x1 0x0 " pmbus_kernel_clk_g        ,1: Clock ‘ CrossRefz ’    is live"
    textline "                   "
    hexmask.long.byte 0x0 27.--27. 0x1 0x0 " otp_kernel_clk_g          ,1: Clock ‘ CrossRefz ’    is live"

; ------------------- CLK_SLEEP_MSK_CNFG member of cgu -------------------

  group 0x0014++0x0003
    line.long 0x000 "CLK_SLEEP_MSK_CNFG, Clock Sleep Mask Configuration Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " se_hosc_clk_g             ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep if  CrossRefz  clock gating control has been enabled"
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " se_rom_clk_g              ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 2.--2. 0x1 0x0 " se_ram1_clk_g             ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 3.--3. 0x1 0x0 " se_ram2_clk_g             ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 4.--4. 0x1 0x0 " se_amba_clk_g             ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 5.--5. 0x1 0x0 " se_dma_clk_g              ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 6.--6. 0x1 0x0 " se_cnfg_otp1_w_clk_g      ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 10.--10. 0x1 0x0 " se_cnfg_dma_clk_g         ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 11.--11. 0x1 0x0 " se_bif_reg_clk_g          ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 12.--12. 0x1 0x0 " se_bif_per_svid_clk_g     ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 13.--13. 0x1 0x0 " se_bif_per_pmbus_clk_g    ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 14.--14. 0x1 0x0 " se_bif_per_ssp_clk_g      ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 15.--15. 0x1 0x0 " se_bif_per_i2c_clk_g      ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 16.--16. 0x1 0x0 " se_bif_per_uart_clk_g     ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 17.--17. 0x1 0x0 " se_dtimer1_clk_g          ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 18.--18. 0x1 0x0 " se_dtimer2_clk_g          ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 19.--19. 0x1 0x0 " se_dtimer3_clk_g          ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 20.--20. 0x1 0x0 " se_wdt_clk_g              ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 21.--21. 0x1 0x0 " se_gpio0_clk_g            ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 22.--22. 0x1 0x0 " se_gpio1_clk_g            ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"

; ---------------- CLK_DEEP_SLEEP_MSK_CNFG member of cgu ----------------

  group 0x0018++0x0003
    line.long 0x000 "CLK_DEEP_SLEEP_MSK?, Clock Deep Sleep Mask Configuration Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " dse_hosc_clk_g            ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in deep sleep if  CrossRefz  clock gating control has been enabled"
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " dse_rom_clk_g             ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in deep sleep"
    textline "                   "
    hexmask.long.byte 0x0 2.--2. 0x1 0x0 " dse_ram1_clk_g            ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in deep sleep"
    textline "                   "
    hexmask.long.byte 0x0 3.--3. 0x1 0x0 " dse_ram2_clk_g            ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in deep sleep"
    textline "                   "
    hexmask.long.byte 0x0 4.--4. 0x1 0x0 " dse_amba_clk_g            ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in deep sleep"
    textline "                   "
    hexmask.long.byte 0x0 5.--5. 0x1 0x0 " dse_dma_clk_g             ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in deep sleep"
    textline "                   "
    hexmask.long.byte 0x0 6.--6. 0x1 0x0 " dse_cnfg_otp1_w_clk1_g    ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in deep sleep"
    textline "                   "
    hexmask.long.byte 0x0 7.--7. 0x1 0x0 " dse_cnfg_otp1_w_clk2_g    ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in deep sleep"
    textline "                   "
    hexmask.long.byte 0x0 8.--8. 0x1 0x0 " dse_cnfg_otp2_w_clk1_g    ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in deep sleep"
    textline "                   "
    hexmask.long.byte 0x0 9.--9. 0x1 0x0 " dse_cnfg_otp2_w_clk2_g    ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in deep sleep"
    textline "                   "
    hexmask.long.byte 0x0 10.--10. 0x1 0x0 " dse_cnfg_dma_clk_g        ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in deep sleep"
    textline "                   "
    hexmask.long.byte 0x0 11.--11. 0x1 0x0 " dse_bif_reg_clk_g         ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in deep sleep"
    textline "                   "
    hexmask.long.byte 0x0 12.--12. 0x1 0x0 " dse_bif_per_svid_clk_g    ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 13.--13. 0x1 0x0 " dse_bif_per_pmbus_clk_g   ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in deep sleep"
    textline "                   "
    hexmask.long.byte 0x0 14.--14. 0x1 0x0 " dse_bif_per_ssp_clk_g     ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in deep sleep"
    textline "                   "
    hexmask.long.byte 0x0 15.--15. 0x1 0x0 " dse_bif_per_i2c_clk_g     ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in deep sleep"
    textline "                   "
    hexmask.long.byte 0x0 16.--16. 0x1 0x0 " dse_bif_per_uart_clk_g    ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in deep sleep"
    textline "                   "
    hexmask.long.byte 0x0 17.--17. 0x1 0x0 " dse_dtimer1_clk_g         ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in dep sleep"
    textline "                   "
    hexmask.long.byte 0x0 18.--18. 0x1 0x0 " dse_dtimer2_clk_g         ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in dep sleep"
    textline "                   "
    hexmask.long.byte 0x0 19.--19. 0x1 0x0 " dse_dtimer3_clk_g         ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in dep sleep"
    textline "                   "
    hexmask.long.byte 0x0 20.--20. 0x1 0x0 " dse_wdt_clk_g             ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in deep sleep"
    textline "                   "
    hexmask.long.byte 0x0 21.--21. 0x1 0x0 " dse_gpio0_clk_g           ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in dep sleep"
    textline "                   "
    hexmask.long.byte 0x0 22.--22. 0x1 0x0 " dse_gpio1_clk_g           ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in dep sleep"

; ---------------- HOSC_SW_CLK_GATING_CTRL member of cgu ----------------

  group 0x001C++0x0003
    line.long 0x000 "HOSC_SW_CLK_GATING?, Hosc SW Clock Gating Control Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " kill_me_softly            ,1: Clock ‘ CrossRefz ’    can be gated"

; ---------------- HOSC_HW_CLK_GATING_CTRL member of cgu ----------------

  group 0x0020++0x0003
    line.long 0x000 "HOSC_HW_CLK_GATING?, Hosc HW Clock Gating Control Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " kill_me_hardly            ,1: Clock ‘ CrossRefz ’    can be gated"

; ------------------------ SPARE_FF member of cgu ------------------------

  group 0x0024++0x0003
    line.long 0x000 "SPARE_FF, Spare Register"
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " SPARE_FF                  ,Spare Register"

; -------------------- CLK_EN_CTRL_SET member of cgu --------------------

  group 0x0030++0x0003
    line.long 0x000 "CLK_EN_CTRL_SET, Clock Enable Control Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " hosc_clk_g                ,1: Clock ‘ CrossRefz ’    is live"
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " rom_clk_g                 ,1: Clock ‘ CrossRefz ’    is live"
    textline "                   "
    hexmask.long.byte 0x0 2.--2. 0x1 0x0 " ram1_clk_g                ,1: Clock ‘ CrossRefz ’    is live"
    textline "                   "
    hexmask.long.byte 0x0 3.--3. 0x1 0x0 " ram2_clk_g                ,1: Clock ‘ CrossRefz ’    is live"
    textline "                   "
    hexmask.long.byte 0x0 4.--4. 0x1 0x0 " amba_clk_g                ,1: Clock ‘ CrossRefz ’    is live"
    textline "                   "
    hexmask.long.byte 0x0 5.--5. 0x1 0x0 " dma_clk_g                 ,1: Clock ‘ CrossRefz ’    is live"
    textline "                   "
    hexmask.long.byte 0x0 6.--6. 0x1 0x0 " cnfg_otp1_w_clk_g         ,1: Clock ‘ CrossRefz ’    and  CrossRefz  are live"
    textline "                   "
    hexmask.long.byte 0x0 10.--10. 0x1 0x0 " cnfg_dma_clk_g            ,1: Clock ‘ CrossRefz ’    and  CrossRefz  are live"
    textline "                   "
    hexmask.long.byte 0x0 11.--11. 0x1 0x0 " bif_reg_clk_g             ,1: Clock ‘ CrossRefz ’    is live"
    textline "                   "
    hexmask.long.byte 0x0 12.--12. 0x1 0x0 " bif_per_svid_clk_g        ,1: Clock ‘ CrossRefz ’    and  CrossRefz  are live"
    textline "                   "
    hexmask.long.byte 0x0 13.--13. 0x1 0x0 " bif_per_pmbus_clk_g       ,1: Clock ‘ CrossRefz ’    and  CrossRefz  are live"
    textline "                   "
    hexmask.long.byte 0x0 14.--14. 0x1 0x0 " bif_per_ssp_clk_g         ,1: Clock ‘ CrossRefz ’    and  CrossRefz  are live"
    textline "                   "
    hexmask.long.byte 0x0 15.--15. 0x1 0x0 " bif_per_i2c_clk_g         ,1: Clock ‘ CrossRefz ’    and  CrossRefz  are live"
    textline "                   "
    hexmask.long.byte 0x0 16.--16. 0x1 0x0 " bif_per_uart_clk_g        ,1: Clock ‘ CrossRefz ’    and  CrossRefz  are live"
    textline "                   "
    hexmask.long.byte 0x0 17.--17. 0x1 0x0 " dtimer1_clk_g             ,1: Clock ‘ CrossRefz ’    and  CrossRefz  are live"
    textline "                   "
    hexmask.long.byte 0x0 18.--18. 0x1 0x0 " dtimer2_clk_g             ,1: Clock ‘ CrossRefz ’    and  CrossRefz  are live"
    textline "                   "
    hexmask.long.byte 0x0 19.--19. 0x1 0x0 " dtimer3_clk_g             ,1: Clock ‘ CrossRefz ’    and  CrossRefz  are live"
    textline "                   "
    hexmask.long.byte 0x0 20.--20. 0x1 0x0 " wdt_clk_g                 ,1: Clock ‘ CrossRefz ’    and  CrossRefz  are live"
    textline "                   "
    hexmask.long.byte 0x0 21.--21. 0x1 0x0 " gpio0_clk_g               ,1: Clock ‘ CrossRefz ’    and  CrossRefz  are live"
    textline "                   "
    hexmask.long.byte 0x0 22.--22. 0x1 0x0 " gpio1_clk_g               ,1: Clock ‘ CrossRefz ’    and  CrossRefz  are live"
    textline "                   "
    hexmask.long.byte 0x0 23.--23. 0x1 0x0 " dtimer1_kernel_clk_g      ,1: Clock ‘ CrossRefz ’    is live"
    textline "                   "
    hexmask.long.byte 0x0 24.--24. 0x1 0x0 " dtimer2_kernel_clk_g      ,1: Clock ‘ CrossRefz ’    is live"
    textline "                   "
    hexmask.long.byte 0x0 25.--25. 0x1 0x0 " dtimer3_kernel_clk_g      ,1: Clock ‘ CrossRefz ’    is live"
    textline "                   "
    hexmask.long.byte 0x0 26.--26. 0x1 0x0 " pmbus_kernel_clk_g        ,1: Clock ‘ CrossRefz ’    is live"
    textline "                   "
    hexmask.long.byte 0x0 27.--27. 0x1 0x0 " otp_kernel_clk_g          ,1: Clock ‘ CrossRefz ’    is live"

; -------------------- CLK_EN_CTRL_CLR member of cgu --------------------

  group 0x0034++0x0003
    line.long 0x000 "CLK_EN_CTRL_CLR, Clock Enable Control Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " hosc_clk_g                ,1: Clock ‘ CrossRefz ’    is live"
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " rom_clk_g                 ,1: Clock ‘ CrossRefz ’    is live"
    textline "                   "
    hexmask.long.byte 0x0 2.--2. 0x1 0x0 " ram1_clk_g                ,1: Clock ‘ CrossRefz ’    is live"
    textline "                   "
    hexmask.long.byte 0x0 3.--3. 0x1 0x0 " ram2_clk_g                ,1: Clock ‘ CrossRefz ’    is live"
    textline "                   "
    hexmask.long.byte 0x0 4.--4. 0x1 0x0 " amba_clk_g                ,1: Clock ‘ CrossRefz ’    is live"
    textline "                   "
    hexmask.long.byte 0x0 5.--5. 0x1 0x0 " dma_clk_g                 ,1: Clock ‘ CrossRefz ’    is live"
    textline "                   "
    hexmask.long.byte 0x0 6.--6. 0x1 0x0 " cnfg_otp1_w_clk_g         ,1: Clock ‘ CrossRefz ’    and  CrossRefz  are live"
    textline "                   "
    hexmask.long.byte 0x0 10.--10. 0x1 0x0 " cnfg_dma_clk_g            ,1: Clock ‘ CrossRefz ’    and  CrossRefz  are live"
    textline "                   "
    hexmask.long.byte 0x0 11.--11. 0x1 0x0 " bif_reg_clk_g             ,1: Clock ‘ CrossRefz ’    is live"
    textline "                   "
    hexmask.long.byte 0x0 12.--12. 0x1 0x0 " bif_per_svid_clk_g        ,1: Clock ‘ CrossRefz ’    and  CrossRefz  are live"
    textline "                   "
    hexmask.long.byte 0x0 13.--13. 0x1 0x0 " bif_per_pmbus_clk_g       ,1: Clock ‘ CrossRefz ’    and  CrossRefz  are live"
    textline "                   "
    hexmask.long.byte 0x0 14.--14. 0x1 0x0 " bif_per_ssp_clk_g         ,1: Clock ‘ CrossRefz ’    and  CrossRefz  are live"
    textline "                   "
    hexmask.long.byte 0x0 15.--15. 0x1 0x0 " bif_per_i2c_clk_g         ,1: Clock ‘ CrossRefz ’    and  CrossRefz  are live"
    textline "                   "
    hexmask.long.byte 0x0 16.--16. 0x1 0x0 " bif_per_uart_clk_g        ,1: Clock ‘ CrossRefz ’    and  CrossRefz  are live"
    textline "                   "
    hexmask.long.byte 0x0 17.--17. 0x1 0x0 " dtimer1_clk_g             ,1: Clock ‘ CrossRefz ’    and  CrossRefz  are live"
    textline "                   "
    hexmask.long.byte 0x0 18.--18. 0x1 0x0 " dtimer2_clk_g             ,1: Clock ‘ CrossRefz ’    and  CrossRefz  are live"
    textline "                   "
    hexmask.long.byte 0x0 19.--19. 0x1 0x0 " dtimer3_clk_g             ,1: Clock ‘ CrossRefz ’    and  CrossRefz  are live"
    textline "                   "
    hexmask.long.byte 0x0 20.--20. 0x1 0x0 " wdt_clk_g                 ,1: Clock ‘ CrossRefz ’    and  CrossRefz  are live"
    textline "                   "
    hexmask.long.byte 0x0 21.--21. 0x1 0x0 " gpio0_clk_g               ,1: Clock ‘ CrossRefz ’    and  CrossRefz  are live"
    textline "                   "
    hexmask.long.byte 0x0 22.--22. 0x1 0x0 " gpio1_clk_g               ,1: Clock ‘ CrossRefz ’    and  CrossRefz  are live"
    textline "                   "
    hexmask.long.byte 0x0 23.--23. 0x1 0x0 " dtimer1_kernel_clk_g      ,1: Clock ‘ CrossRefz ’    is live"
    textline "                   "
    hexmask.long.byte 0x0 24.--24. 0x1 0x0 " dtimer2_kernel_clk_g      ,1: Clock ‘ CrossRefz ’    is live"
    textline "                   "
    hexmask.long.byte 0x0 25.--25. 0x1 0x0 " dtimer3_kernel_clk_g      ,1: Clock ‘ CrossRefz ’    is live"
    textline "                   "
    hexmask.long.byte 0x0 26.--26. 0x1 0x0 " pmbus_kernel_clk_g        ,1: Clock ‘ CrossRefz ’    is live"
    textline "                   "
    hexmask.long.byte 0x0 27.--27. 0x1 0x0 " otp_kernel_clk_g          ,1: Clock ‘ CrossRefz ’    is live"

; ----------------- CLK_SLEEP_MSK_CNFG_SET member of cgu -----------------

  group 0x0038++0x0003
    line.long 0x000 "CLK_SLEEP_MSK_CNFG?, Clock Sleep Mask Configuration Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " se_hosc_clk_g             ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep if  CrossRefz  clock gating control has been enabled"
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " se_rom_clk_g              ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 2.--2. 0x1 0x0 " se_ram1_clk_g             ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 3.--3. 0x1 0x0 " se_ram2_clk_g             ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 4.--4. 0x1 0x0 " se_amba_clk_g             ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 5.--5. 0x1 0x0 " se_dma_clk_g              ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 6.--6. 0x1 0x0 " se_cnfg_otp1_w_clk_g      ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 10.--10. 0x1 0x0 " se_cnfg_dma_clk_g         ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 11.--11. 0x1 0x0 " se_bif_reg_clk_g          ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 12.--12. 0x1 0x0 " se_bif_per_svid_clk_g     ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 13.--13. 0x1 0x0 " se_bif_per_pmbus_clk_g    ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 14.--14. 0x1 0x0 " se_bif_per_ssp_clk_g      ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 15.--15. 0x1 0x0 " se_bif_per_i2c_clk_g      ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 16.--16. 0x1 0x0 " se_bif_per_uart_clk_g     ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 17.--17. 0x1 0x0 " se_dtimer1_clk_g          ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 18.--18. 0x1 0x0 " se_dtimer2_clk_g          ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 19.--19. 0x1 0x0 " se_dtimer3_clk_g          ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 20.--20. 0x1 0x0 " se_wdt_clk_g              ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 21.--21. 0x1 0x0 " se_gpio0_clk_g            ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 22.--22. 0x1 0x0 " se_gpio1_clk_g            ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"

; ----------------- CLK_SLEEP_MSK_CNFG_CLR member of cgu -----------------

  group 0x003C++0x0003
    line.long 0x000 "CLK_SLEEP_MSK_CNFG?, Clock Sleep Mask Configuration Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " se_hosc_clk_g             ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep if  CrossRefz  clock gating control has been enabled"
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " se_rom_clk_g              ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 2.--2. 0x1 0x0 " se_ram1_clk_g             ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 3.--3. 0x1 0x0 " se_ram2_clk_g             ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 4.--4. 0x1 0x0 " se_amba_clk_g             ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 5.--5. 0x1 0x0 " se_dma_clk_g              ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 6.--6. 0x1 0x0 " se_cnfg_otp1_w_clk_g      ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 10.--10. 0x1 0x0 " se_cnfg_dma_clk_g         ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 11.--11. 0x1 0x0 " se_bif_reg_clk_g          ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 12.--12. 0x1 0x0 " se_bif_per_svid_clk_g     ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 13.--13. 0x1 0x0 " se_bif_per_pmbus_clk_g    ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 14.--14. 0x1 0x0 " se_bif_per_ssp_clk_g      ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 15.--15. 0x1 0x0 " se_bif_per_i2c_clk_g      ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 16.--16. 0x1 0x0 " se_bif_per_uart_clk_g     ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 17.--17. 0x1 0x0 " se_dtimer1_clk_g          ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 18.--18. 0x1 0x0 " se_dtimer2_clk_g          ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 19.--19. 0x1 0x0 " se_dtimer3_clk_g          ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 20.--20. 0x1 0x0 " se_wdt_clk_g              ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 21.--21. 0x1 0x0 " se_gpio0_clk_g            ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 22.--22. 0x1 0x0 " se_gpio1_clk_g            ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"

; -------------- CLK_DEEP_SLEEP_MSK_CNFG_SET member of cgu --------------

  group 0x0040++0x0003
    line.long 0x000 "CLK_DEEP_SLEEP_MSK?, Clock Deep Sleep Mask Configuration Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " dse_hosc_clk_g            ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in deep sleep if  CrossRefz  clock gating control has been enabled"
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " dse_rom_clk_g             ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in deep sleep"
    textline "                   "
    hexmask.long.byte 0x0 2.--2. 0x1 0x0 " dse_ram1_clk_g            ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in deep sleep"
    textline "                   "
    hexmask.long.byte 0x0 3.--3. 0x1 0x0 " dse_ram2_clk_g            ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in deep sleep"
    textline "                   "
    hexmask.long.byte 0x0 4.--4. 0x1 0x0 " dse_amba_clk_g            ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in deep sleep"
    textline "                   "
    hexmask.long.byte 0x0 5.--5. 0x1 0x0 " dse_dma_clk_g             ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in deep sleep"
    textline "                   "
    hexmask.long.byte 0x0 6.--6. 0x1 0x0 " dse_cnfg_otp1_w_clk_g     ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in deep sleep"
    textline "                   "
    hexmask.long.byte 0x0 10.--10. 0x1 0x0 " dse_cnfg_dma_clk_g        ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in deep sleep"
    textline "                   "
    hexmask.long.byte 0x0 11.--11. 0x1 0x0 " dse_bif_reg_clk_g         ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in deep sleep"
    textline "                   "
    hexmask.long.byte 0x0 12.--12. 0x1 0x0 " dse_bif_per_svid_clk_g    ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 13.--13. 0x1 0x0 " dse_bif_per_pmbus_clk_g   ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in deep sleep"
    textline "                   "
    hexmask.long.byte 0x0 14.--14. 0x1 0x0 " dse_bif_per_ssp_clk_g     ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in deep sleep"
    textline "                   "
    hexmask.long.byte 0x0 15.--15. 0x1 0x0 " dse_bif_per_i2c_clk_g     ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in deep sleep"
    textline "                   "
    hexmask.long.byte 0x0 16.--16. 0x1 0x0 " dse_bif_per_uart_clk_g    ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in deep sleep"
    textline "                   "
    hexmask.long.byte 0x0 17.--17. 0x1 0x0 " dse_dtimer1_clk_g         ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in dep sleep"
    textline "                   "
    hexmask.long.byte 0x0 18.--18. 0x1 0x0 " dse_dtimer2_clk_g         ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in dep sleep"
    textline "                   "
    hexmask.long.byte 0x0 19.--19. 0x1 0x0 " dse_dtimer3_clk_g         ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in dep sleep"
    textline "                   "
    hexmask.long.byte 0x0 20.--20. 0x1 0x0 " dse_wdt_clk_g             ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in deep sleep"
    textline "                   "
    hexmask.long.byte 0x0 21.--21. 0x1 0x0 " dse_gpio0_clk_g           ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in dep sleep"
    textline "                   "
    hexmask.long.byte 0x0 22.--22. 0x1 0x0 " dse_gpio1_clk_g           ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in dep sleep"

; -------------- CLK_DEEP_SLEEP_MSK_CNFG_CLR member of cgu --------------

  group 0x0044++0x0003
    line.long 0x000 "CLK_DEEP_SLEEP_MSK?, Clock Deep Sleep Mask Configuration Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " dse_hosc_clk_g            ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in deep sleep if  CrossRefz  clock gating control has been enabled"
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " dse_rom_clk_g             ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in deep sleep"
    textline "                   "
    hexmask.long.byte 0x0 2.--2. 0x1 0x0 " dse_ram1_clk_g            ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in deep sleep"
    textline "                   "
    hexmask.long.byte 0x0 3.--3. 0x1 0x0 " dse_ram2_clk_g            ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in deep sleep"
    textline "                   "
    hexmask.long.byte 0x0 4.--4. 0x1 0x0 " dse_amba_clk_g            ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in deep sleep"
    textline "                   "
    hexmask.long.byte 0x0 5.--5. 0x1 0x0 " dse_dma_clk_g             ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in deep sleep"
    textline "                   "
    hexmask.long.byte 0x0 6.--6. 0x1 0x0 " dse_cnfg_otp1_w_clk_g     ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in deep sleep"
    textline "                   "
    hexmask.long.byte 0x0 10.--10. 0x1 0x0 " dse_cnfg_dma_clk_g        ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in deep sleep"
    textline "                   "
    hexmask.long.byte 0x0 11.--11. 0x1 0x0 " dse_bif_reg_clk_g         ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in deep sleep"
    textline "                   "
    hexmask.long.byte 0x0 12.--12. 0x1 0x0 " dse_bif_per_svid_clk_g    ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in sleep"
    textline "                   "
    hexmask.long.byte 0x0 13.--13. 0x1 0x0 " dse_bif_per_pmbus_clk_g   ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in deep sleep"
    textline "                   "
    hexmask.long.byte 0x0 14.--14. 0x1 0x0 " dse_bif_per_ssp_clk_g     ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in deep sleep"
    textline "                   "
    hexmask.long.byte 0x0 15.--15. 0x1 0x0 " dse_bif_per_i2c_clk_g     ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in deep sleep"
    textline "                   "
    hexmask.long.byte 0x0 16.--16. 0x1 0x0 " dse_bif_per_uart_clk_g    ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in deep sleep"
    textline "                   "
    hexmask.long.byte 0x0 17.--17. 0x1 0x0 " dse_dtimer1_clk_g         ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in dep sleep"
    textline "                   "
    hexmask.long.byte 0x0 18.--18. 0x1 0x0 " dse_dtimer2_clk_g         ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in dep sleep"
    textline "                   "
    hexmask.long.byte 0x0 19.--19. 0x1 0x0 " dse_dtimer3_clk_g         ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in dep sleep"
    textline "                   "
    hexmask.long.byte 0x0 20.--20. 0x1 0x0 " dse_wdt_clk_g             ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in deep sleep"
    textline "                   "
    hexmask.long.byte 0x0 21.--21. 0x1 0x0 " dse_gpio0_clk_g           ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in dep sleep"
    textline "                   "
    hexmask.long.byte 0x0 22.--22. 0x1 0x0 " dse_gpio1_clk_g           ,1: Clock ‘ CrossRefz ’    is gated when CM0 is in dep sleep"

tree.end

; -------------------------------------------------------------------
; End Block - cgu
; -------------------------------------------------------------------
tree.end
; @file:      common.per
; Chip name:  SHASTA
; Module:     common
; 
; Generated by the pmm metagen library.
;
; ===================================================================
; Copyright (C) 2018 Infineon Technologies AG
; All rights reserved.
; ===================================================================
;
; ===================================================================
; This document contains proprietary information. Passing on and
; copying of this document, and communication of its contents is not
; permitted without prior written authorisation.
; ===================================================================

; This file is automatically generated. Do not edit!


config 32. 8.
width 20.

tree "Block - common"
; -------------------------------------------------------------------
; Begin Block - common
; -------------------------------------------------------------------
base D:0x70003000

tree "common"
; --------------------- BALANCE_CFG member of common ---------------------

  group 0x0000++0x0003
    line.long 0x000 "BALANCE_CFG, Current balance PI filter proportional coefficient index.  Set to 0 to disable the proportional component of the filter.  Note that index settings greater than 55 are clamped to 55. "
    textline "                   "
    hexmask.long.byte 0x0 0.--5. 0x1 0x0 " kp_ibal                   ,Current balance PI filter proportional coefficient index.  Set to 0 to disable the proportional component of the filter.  Note that index settings greater than 55 are clamped to 55. "
    textline "                   "
    hexmask.long.byte 0x0 6.--11. 0x1 0x0 " ki_ibal                   ,Current balance PI filter integral coefficient index.  Set to 0 to disable the integral component of the filter.  Note that index settings greater than 55 are clamped to 55. "
    textline "                   "
    hexmask.long.byte 0x0 12.--17. 0x1 0x0 " kp_fbal                   ,Flux/Voltage balance PI filter proportional coefficient index.  Set to 0 to disable the proportional component of the filter.  Note that index settings greater than 55 are clamped to 55.  Note also that flux balancing is only functional when duty cycle locking is enabled by rampX_dutyc_lock. "
    textline "                   "
    hexmask.long.byte 0x0 18.--23. 0x1 0x0 " ki_fbal                   ,Flux/Voltage balance PI filter integral coefficient index.  Set to 0 to disable the integral component of the filter.  Note that index settings greater than 55 are clamped to 55.  Note also that flux balancing is only functional when duty cycle locking is enabled by rampX_dutyc_lock. "
    textline "                   "
    hexmask.long.byte 0x0 24.--24. 0x1 0x0 " vbal_mode_sel             ,Flux / Voltage balance filter mode select "
    textline "                   "
    hexmask.long.byte 0x0 25.--25. 0x1 0x0 " ical_en                   ,Current sense sensor offset autocalibration enable. "
    textline "                   "
    hexmask.long.byte 0x0 26.--27. 0x1 0x0 " ibal_en_thresh            ,Total current level above which current balancing is enabled in interleaved (multi-phase) topologies.  Set to higher value if concerned about low current accuracy. "
    textline "                   "
    hexmask.long.byte 0x0 28.--28. 0x1 0x0 " fbal_time_only            ,In the flux balance mode of the Flux / voltage balance PI filter, select between volt-second or time only balancing. "

; ---------------------- MP_FUNC1 member of common ----------------------

  group 0x0004++0x0003
    line.long 0x000 "MP_FUNC1, Pin BEN function definition "
    textline "                   "
    hexmask.long.byte 0x0 0.--2. 0x1 0x0 " ben_func                  ,Pin BEN function definition "
    textline "                   "
    hexmask.long.byte 0x0 3.--3. 0x1 0x0 " ben_pd                    ,Pin BEN weak pulldown enable "
    textline "                   "
    hexmask.long.byte 0x0 4.--4. 0x1 0x0 " ben_pu_n                  ,Pin BEN weak pullup enable "
    textline "                   "
    hexmask.long.byte 0x0 5.--5. 0x1 0x0 " ben_ppen                  ,Pin BEN output buffer CMOS / Open Drain select "
    textline "                   "
    hexmask.long.byte 0x0 6.--8. 0x1 0x0 " bpwrgd_func               ,Pin BPWRGD function definition "
    textline "                   "
    hexmask.long.byte 0x0 9.--9. 0x1 0x0 " bpwrgd_pd                 ,Pin BPWRGD weak pulldown enable "
    textline "                   "
    hexmask.long.byte 0x0 10.--10. 0x1 0x0 " bpwrgd_pu_n               ,Pin BPWRGD weak pullup enable "
    textline "                   "
    hexmask.long.byte 0x0 11.--11. 0x1 0x0 " bpwrgd_ppen               ,Pin BPWRGD output buffer CMOS / Open Drain select "
    textline "                   "
    hexmask.long.byte 0x0 12.--14. 0x1 0x0 " en_func                   ,Pin EN function definition "
    textline "                   "
    hexmask.long.byte 0x0 15.--15. 0x1 0x0 " en_pd                     ,Pin EN weak pulldown enable "
    textline "                   "
    hexmask.long.byte 0x0 16.--16. 0x1 0x0 " en_pu_n                   ,Pin EN weak pullup enable "
    textline "                   "
    hexmask.long.byte 0x0 17.--17. 0x1 0x0 " en_ppen                   ,Pin EN output buffer CMOS / Open Drain select "
    textline "                   "
    hexmask.long.byte 0x0 18.--20. 0x1 0x0 " fault1_func               ,Pin FAULT1 function definition "
    textline "                   "
    hexmask.long.byte 0x0 21.--21. 0x1 0x0 " fault1_pd                 ,Pin FAULT1 weak pulldown enable "
    textline "                   "
    hexmask.long.byte 0x0 22.--22. 0x1 0x0 " fault1_pu_n               ,Pin FAULT1 weak pullup enable "
    textline "                   "
    hexmask.long.byte 0x0 23.--23. 0x1 0x0 " fault1_ppen               ,Pin FAULT1 output buffer CMOS / Open Drain select "
    textline "                   "
    hexmask.long.byte 0x0 24.--26. 0x1 0x0 " fault2_func               ,Pin FAULT2 function definition "
    textline "                   "
    hexmask.long.byte 0x0 27.--27. 0x1 0x0 " fault2_pd                 ,Pin FAULT2 weak pulldown enable "
    textline "                   "
    hexmask.long.byte 0x0 28.--28. 0x1 0x0 " fault2_pu_n               ,Pin FAULT2 weak pullup enable "
    textline "                   "
    hexmask.long.byte 0x0 29.--29. 0x1 0x0 " fault2_ppen               ,Pin FAULT2 output buffer CMOS / Open Drain select "

; ---------------------- MP_FUNC2 member of common ----------------------

  group 0x0008++0x0003
    line.long 0x000 "MP_FUNC2, Pin IMON function definition "
    textline "                   "
    hexmask.long.byte 0x0 0.--2. 0x1 0x0 " imon_func                 ,Pin IMON function definition "
    textline "                   "
    hexmask.long.byte 0x0 3.--3. 0x1 0x0 " imon_pd                   ,Pin IMON weak pulldown enable "
    textline "                   "
    hexmask.long.byte 0x0 4.--4. 0x1 0x0 " imon_pu_n                 ,Pin IMON weak pullup enable "
    textline "                   "
    hexmask.long.byte 0x0 5.--5. 0x1 0x0 " imon_ppen                 ,Pin IMON output buffer CMOS / Open Drain select "
    textline "                   "
    hexmask.long.byte 0x0 6.--8. 0x1 0x0 " pwrgd_func                ,Pin PWRGD function definition "
    textline "                   "
    hexmask.long.byte 0x0 9.--9. 0x1 0x0 " pwrgd_pd                  ,Pin PWRGD weak pulldown enable "
    textline "                   "
    hexmask.long.byte 0x0 10.--10. 0x1 0x0 " pwrgd_pu_n                ,Pin PWRGD weak pullup enable "
    textline "                   "
    hexmask.long.byte 0x0 11.--11. 0x1 0x0 " pwrgd_ppen                ,Pin PWRGD output buffer CMOS / Open Drain select "
    textline "                   "
    hexmask.long.byte 0x0 12.--14. 0x1 0x0 " smbalert_func             ,Pin SMBALERT function definition "
    textline "                   "
    hexmask.long.byte 0x0 15.--15. 0x1 0x0 " smbalert_pd               ,Pin SMBALERT weak pulldown enable "
    textline "                   "
    hexmask.long.byte 0x0 16.--16. 0x1 0x0 " smbalert_pu_n             ,Pin SMBALERT weak pullup enable "
    textline "                   "
    hexmask.long.byte 0x0 17.--17. 0x1 0x0 " smbalert_ppen             ,Pin SMBALERT output buffer CMOS / Open Drain select "
    textline "                   "
    hexmask.long.byte 0x0 18.--20. 0x1 0x0 " sync_func                 ,Pin SYNC function definition "
    textline "                   "
    hexmask.long.byte 0x0 21.--21. 0x1 0x0 " sync_pd                   ,Pin SYNC weak pulldown enable "
    textline "                   "
    hexmask.long.byte 0x0 22.--22. 0x1 0x0 " sync_pu_n                 ,Pin SYNC weak pullup enable "
    textline "                   "
    hexmask.long.byte 0x0 23.--23. 0x1 0x0 " sync_ppen                 ,Pin SYNC output buffer CMOS / Open Drain select "
    textline "                   "
    hexmask.long.byte 0x0 24.--24. 0x1 0x0 " scl_pd                    ,Pin SCL weak pulldown enable "
    textline "                   "
    hexmask.long.byte 0x0 25.--25. 0x1 0x0 " scl_en_3v3                ,Pin SCL 1.8V / 3.3V input threshold select "
    textline "                   "
    hexmask.long.byte 0x0 26.--26. 0x1 0x0 " sda_pd                    ,Pin SDA weak pulldown enable "
    textline "                   "
    hexmask.long.byte 0x0 27.--27. 0x1 0x0 " sda_en_3v3                ,Pin SDA 1.8V / 3.3V input threshold select "
    textline "                   "
    hexmask.long.byte 0x0 28.--28. 0x1 0x0 " sync_deglitch_en          ,Deglitch enable for digital sync function when used as an input. "

; ---------------------- MP_FUNC3 member of common ----------------------

  group 0x000C++0x0003
    line.long 0x000 "MP_FUNC3, Pin PWM1 function definition "
    textline "                   "
    hexmask.long.byte 0x0 0.--2. 0x1 0x0 " pwm1_func                 ,Pin PWM1 function definition "
    textline "                   "
    hexmask.long.byte 0x0 3.--3. 0x1 0x0 " pwm1_pd                   ,Pin PWM1 weak pulldown enable "
    textline "                   "
    hexmask.long.byte 0x0 4.--4. 0x1 0x0 " pwm1_pu_n                 ,Pin PWM1 weak pullup enable "
    textline "                   "
    hexmask.long.byte 0x0 5.--5. 0x1 0x0 " pwm1_ppen                 ,Pin PWM1 output buffer CMOS / Open Drain select "
    textline "                   "
    hexmask.long.byte 0x0 6.--8. 0x1 0x0 " pwm2_func                 ,Pin PWM2 function definition "
    textline "                   "
    hexmask.long.byte 0x0 9.--9. 0x1 0x0 " pwm2_pd                   ,Pin PWM2 weak pulldown enable "
    textline "                   "
    hexmask.long.byte 0x0 10.--10. 0x1 0x0 " pwm2_pu_n                 ,Pin PWM2 weak pullup enable "
    textline "                   "
    hexmask.long.byte 0x0 11.--11. 0x1 0x0 " pwm2_ppen                 ,Pin PWM2 output buffer CMOS / Open Drain select "
    textline "                   "
    hexmask.long.byte 0x0 12.--14. 0x1 0x0 " pwm3_func                 ,Pin PWM3 function definition "
    textline "                   "
    hexmask.long.byte 0x0 15.--15. 0x1 0x0 " pwm3_pd                   ,Pin PWM3 weak pulldown enable "
    textline "                   "
    hexmask.long.byte 0x0 16.--16. 0x1 0x0 " pwm3_pu_n                 ,Pin PWM3 weak pullup enable "
    textline "                   "
    hexmask.long.byte 0x0 17.--17. 0x1 0x0 " pwm3_ppen                 ,Pin PWM3 output buffer CMOS / Open Drain select "
    textline "                   "
    hexmask.long.byte 0x0 18.--20. 0x1 0x0 " pwm4_func                 ,Pin PWM4 function definition "
    textline "                   "
    hexmask.long.byte 0x0 21.--21. 0x1 0x0 " pwm4_pd                   ,Pin PWM4 weak pulldown enable "
    textline "                   "
    hexmask.long.byte 0x0 22.--22. 0x1 0x0 " pwm4_pu_n                 ,Pin PWM4 weak pullup enable "
    textline "                   "
    hexmask.long.byte 0x0 23.--23. 0x1 0x0 " pwm4_ppen                 ,Pin PWM4 output buffer CMOS / Open Drain select "
    textline "                   "
    hexmask.long.byte 0x0 24.--26. 0x1 0x0 " pwm5_func                 ,Pin PWM5 function definition "
    textline "                   "
    hexmask.long.byte 0x0 27.--27. 0x1 0x0 " pwm5_pd                   ,Pin PWM5 weak pulldown enable "
    textline "                   "
    hexmask.long.byte 0x0 28.--28. 0x1 0x0 " pwm5_pu_n                 ,Pin PWM5 weak pullup enable "
    textline "                   "
    hexmask.long.byte 0x0 29.--29. 0x1 0x0 " pwm5_ppen                 ,Pin PWM5 output buffer CMOS / Open Drain select "

; ---------------------- MP_FUNC4 member of common ----------------------

  group 0x0010++0x0003
    line.long 0x000 "MP_FUNC4, Pin PWM6 function definition "
    textline "                   "
    hexmask.long.byte 0x0 0.--2. 0x1 0x0 " pwm6_func                 ,Pin PWM6 function definition "
    textline "                   "
    hexmask.long.byte 0x0 3.--3. 0x1 0x0 " pwm6_pd                   ,Pin PWM6 weak pulldown enable "
    textline "                   "
    hexmask.long.byte 0x0 4.--4. 0x1 0x0 " pwm6_pu_n                 ,Pin PWM6 weak pullup enable "
    textline "                   "
    hexmask.long.byte 0x0 5.--5. 0x1 0x0 " pwm6_ppen                 ,Pin PWM6 output buffer CMOS / Open Drain select "
    textline "                   "
    hexmask.long.byte 0x0 6.--8. 0x1 0x0 " pwm7_func                 ,Pin PWM7 function definition "
    textline "                   "
    hexmask.long.byte 0x0 9.--9. 0x1 0x0 " pwm7_pd                   ,Pin PWM7 weak pulldown enable "
    textline "                   "
    hexmask.long.byte 0x0 10.--10. 0x1 0x0 " pwm7_pu_n                 ,Pin PWM7 weak pullup enable "
    textline "                   "
    hexmask.long.byte 0x0 11.--11. 0x1 0x0 " pwm7_ppen                 ,Pin PWM7 output buffer CMOS / Open Drain select "
    textline "                   "
    hexmask.long.byte 0x0 12.--14. 0x1 0x0 " pwm8_func                 ,Pin PWM8 function definition "
    textline "                   "
    hexmask.long.byte 0x0 15.--15. 0x1 0x0 " pwm8_pd                   ,Pin PWM8 weak pulldown enable "
    textline "                   "
    hexmask.long.byte 0x0 16.--16. 0x1 0x0 " pwm8_pu_n                 ,Pin PWM8 weak pullup enable "
    textline "                   "
    hexmask.long.byte 0x0 17.--17. 0x1 0x0 " pwm8_ppen                 ,Pin PWM8 output buffer CMOS / Open Drain select "
    textline "                   "
    hexmask.long.byte 0x0 18.--20. 0x1 0x0 " pwm9_func                 ,Pin PWM9 function definition "
    textline "                   "
    hexmask.long.byte 0x0 21.--21. 0x1 0x0 " pwm9_pd                   ,Pin PWM9 weak pulldown enable "
    textline "                   "
    hexmask.long.byte 0x0 22.--22. 0x1 0x0 " pwm9_pu_n                 ,Pin PWM9 weak pullup enable "
    textline "                   "
    hexmask.long.byte 0x0 23.--23. 0x1 0x0 " pwm9_ppen                 ,Pin PWM9 output buffer CMOS / Open Drain select "
    textline "                   "
    hexmask.long.byte 0x0 24.--26. 0x1 0x0 " pwm10_func                ,Pin PWM10 function definition "
    textline "                   "
    hexmask.long.byte 0x0 27.--27. 0x1 0x0 " pwm10_pd                  ,Pin PWM10 weak pulldown enable "
    textline "                   "
    hexmask.long.byte 0x0 28.--28. 0x1 0x0 " pwm10_pu_n                ,Pin PWM10 weak pullup enable "
    textline "                   "
    hexmask.long.byte 0x0 29.--29. 0x1 0x0 " pwm10_ppen                ,Pin PWM10 output buffer CMOS / Open Drain select "
    textline "                   "
    hexmask.long.byte 0x0 30.--30. 0x1 0x0 " pwm6_static_hiz           ,Pin PWM6 Static HiZ control.  Pin PWM6 has a special otput buffer with Tri-state bias resistors for use with integrated power stage drivers. "
    textline "                   "
    hexmask.long.byte 0x0 31.--31. 0x1 0x0 " force_pwm56_in_en_n       ,For test use only.  Set to 1 for normal operation. "

; ---------------------- MP_FUNC5 member of common ----------------------

  group 0x0014++0x0003
    line.long 0x000 "MP_FUNC5, Pin PWM11 function definition "
    textline "                   "
    hexmask.long.byte 0x0 0.--2. 0x1 0x0 " pwm11_func                ,Pin PWM11 function definition "
    textline "                   "
    hexmask.long.byte 0x0 3.--3. 0x1 0x0 " pwm11_pd                  ,Pin PWM11 weak pulldown enable "
    textline "                   "
    hexmask.long.byte 0x0 4.--4. 0x1 0x0 " pwm11_pu_n                ,Pin PWM11 weak pullup enable "
    textline "                   "
    hexmask.long.byte 0x0 5.--5. 0x1 0x0 " pwm11_ppen                ,Pin PWM11 output buffer CMOS / Open Drain select "
    textline "                   "
    hexmask.long.byte 0x0 6.--8. 0x1 0x0 " pwm12_func                ,Pin PWM12 function definition "
    textline "                   "
    hexmask.long.byte 0x0 9.--9. 0x1 0x0 " pwm12_pd                  ,Pin PWM12 weak pulldown enable "
    textline "                   "
    hexmask.long.byte 0x0 10.--10. 0x1 0x0 " pwm12_pu_n                ,Pin PWM12 weak pullup enable "
    textline "                   "
    hexmask.long.byte 0x0 11.--11. 0x1 0x0 " pwm12_ppen                ,Pin PWM12 output buffer CMOS / Open Drain select "
    textline "                   "
    hexmask.long.byte 0x0 12.--12. 0x1 0x0 " pwm11_static_hiz          ,Pin PWM11 Static HiZ control.  Pin PWM11 has a special otput buffer with Tri-state bias resistors for use with integrated power stage drivers. "
    textline "                   "
    hexmask.long.byte 0x0 13.--13. 0x1 0x0 " sync_dir_out              ,Defines direction of pin mapped to SYNC function "
    textline "                   "
    hexmask.long.byte 0x0 14.--14. 0x1 0x0 " gpio1_dat_n               ,Not used"
    textline "                   "
    hexmask.long.byte 0x0 15.--15. 0x1 0x0 " gpio1_ibuf_en_n           ,Not used"
    textline "                   "
    hexmask.long.byte 0x0 16.--16. 0x1 0x0 " gpio1_obuf_en_n           ,Not used"
    textline "                   "
    hexmask.long.byte 0x0 17.--17. 0x1 0x0 " gpio1_pullup_n            ,Not used"
    textline "                   "
    hexmask.long.byte 0x0 18.--18. 0x1 0x0 " gpio1_pd                  ,Not used"
    textline "                   "
    hexmask.long.byte 0x0 19.--19. 0x1 0x0 " gpio1_ppen                ,Not used"
    textline "                   "
    hexmask.long.byte 0x0 20.--22. 0x1 0x0 " gpio_dly                  ,Defines deglitch time on GPIO input buffers.  The GPIO input must be stable for the defined time (clocked at 25MHz) to be passed through the deglitcher.  A setting of 0 disables the deglitch function.  This register applies to all GPIO inputs."
    textline "                   "
    hexmask.long.byte 0x0 23.--30. 0x1 0x0 " fbal_max                  ,Flux / Voltage balance max correction.  This register limits the maximum duty cycle correction applied by the flux balance filter."

; ----------------------- VRS_CFG member of common -----------------------

  group 0x0018++0x0003
    line.long 0x000 "VRS_CFG, Vrect comparator watchdog timeout threshold.  The watchdog timer measures from the rising edge of the PWM's indicated in ceX_on_mask0 and ceX_on_mask1.  If Vrect has not tripped the comparator by the time the timeout threshold is reached, it is assumed Vrect is below the comparator threshold and the Vrect sense will enter its hold phase.  This threshold should be set to a value greater than the expected time for Vrect to go high but less than the tracking start threshold defined by vrs_track_start_thr.  This threshold is shared by VRS1 and VRS2."
    textline "                   "
    hexmask.long.word 0x0 0.--9. 0x1 0x0 " vrs_cmp_wdt_thr           ,Vrect comparator watchdog timeout threshold.  The watchdog timer measures from the rising edge of the PWM's indicated in ceX_on_mask0 and ceX_on_mask1.  If Vrect has not tripped the comparator by the time the timeout threshold is reached, it is assumed Vrect is below the comparator threshold and the Vrect sense will enter its hold phase.  This threshold should be set to a value greater than the expected time for Vrect to go high but less than the tracking start threshold defined by vrs_track_start_thr.  This threshold is shared by VRS1 and VRS2."
    textline "                   "
    hexmask.long.word 0x0 10.--19. 0x1 0x0 " vrs_track_start_thr       ,Vrect tracking start time threshold.  This threshold is compared against the same timer used by vrs_cmp_wdt_thr which is started on the rising edge of the PWM's indicated in ceX_on_mask0 and ceX_on_mask1.  When the timer exceeds this threshold the Vrect sense moves from its hold phase to its tracking phase.  This threshold should be set approximately 250ns above the expected time of arrival of the Vrect rising edge to insure adequate settling of the analog front end.  This threshold is shared by VRS1 and VRS2."
    textline "                   "
    hexmask.long.byte 0x0 20.--20. 0x1 0x0 " vrect_div_2_sel           ,Defines equation used for rectification voltage (Vrect) measurement. "
    textline "                   "
    hexmask.long.byte 0x0 21.--21. 0x1 0x0 " vsp1_vrs_sel              ,VS1 (VRSEN) ADC rectification voltage sense (VRS) mode select. "
    textline "                   "
    hexmask.long.byte 0x0 22.--22. 0x1 0x0 " vsp2_vrs_sel              ,VS2 (BVSEN_BVRSEN) ADC rectification voltage sense (VRS) mode select. "
    textline "                   "
    hexmask.long.byte 0x0 23.--24. 0x1 0x0 " vsp1_vrs_cnt_num_avg      ,Defines the number of samples in the VRS1 dead time measurement block averagers.  The dead time measurements inlcude SR FET falling edge to VRS Comp rising edge and VRS Comp falling edge to SR FET rising edge. "
    textline "                   "
    hexmask.long.byte 0x0 25.--26. 0x1 0x0 " vsp2_vrs_cnt_num_avg      ,Defines the number of samples in the VRS2 dead time measurement block averagers.  The dead time measurements inlcude SR FET falling edge to VRS Comp rising edge and VRS Comp falling edge to SR FET rising edge. "
    textline "                   "
    hexmask.long.byte 0x0 27.--27. 0x1 0x0 " vrs_cmp_ref_sel           ,Rectification voltage sense (VRS) comparator threshold select.  This threshold is shared by VRS1 and VRS2.  When the rectification voltage exceeds this threshold the VRS enters its hold phase of operation. "
    textline "                   "
    hexmask.long.byte 0x0 28.--28. 0x1 0x0 " vrs_delta_vsum_sel        ,In the VRS tracking phase, the ADC output is filtered by both a fast (higher bandwidth) LPF and a slow (lower bandwidth) LPF.  When the difference between the two LPF outputs is greater than the threshold selected by vrs_delta_vsum_sel, the fast filter output is selected, otherwise the slow filter output is selected. "
    textline "                   "
    hexmask.long.byte 0x0 29.--29. 0x1 0x0 " vrs_bypass_slow_lpf       ,VRS slow filter bypass control.  Shared by VRS1 and VRS2. "
    textline "                   "
    hexmask.long.byte 0x0 30.--30. 0x1 0x0 " vrs_bypass_fast_lpf       ,VRS fast filter bypass control.  Shared by VRS1 and VRS2. "

; ------------------ VRS_VOLTAGE_INIT member of common ------------------

  group 0x001C++0x0003
    line.long 0x000 "VRS_VOLTAGE_INIT, Initial voltage for VS1 (VRSEN) and VS2 (BVSEN_BVRSEN) tracking integrators when operating in VRS mode.  This setting must be greater than the rectification voltage corresponding to VIN_ON for controller startup when a rectification voltage is selcted for the input voltage telemetry input source by tlm_vin_src_sel."
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " vrs_voltage_init          ,Initial voltage for VS1 (VRSEN) and VS2 (BVSEN_BVRSEN) tracking integrators when operating in VRS mode.  This setting must be greater than the rectification voltage corresponding to VIN_ON for controller startup when a rectification voltage is selcted for the input voltage telemetry input source by tlm_vin_src_sel."
    textline "                   "
    hexmask.long.byte 0x0 8.--8. 0x1 0x0 " vrs_same_cycle_en         ,VRS same cycle mode enable.  When enabled, live Vrect updates will begin vrs_meas_start_thr samples after entering tracking mode for faster feed forward response.  Otherwise Vrect will only be updated on the falling PWM edge. "
    textline "                   "
    hexmask.long.byte 0x0 9.--11. 0x1 0x0 " vrs_min_pw                ,VRS deglitch pulse width."
    textline "                   "
    hexmask.long.byte 0x0 12.--16. 0x1 0x0 " vrs_meas_start_thr        ,VRS same cycle sample count before going to live updates."

; ----------------------- ISHARE member of common -----------------------

  group 0x0020++0x0003
    line.long 0x000 "ISHARE, Used for current sharing, this register defines a pre-scale gain applied to the internal current telemetry before sending to the current output DAC on the IMON pin.  It setting should be computed as follows: "
    textline "                   "
    hexmask.long.byte 0x0 0.--4. 0x1 0x0 " ishr_scale                ,Used for current sharing, this register defines a pre-scale gain applied to the internal current telemetry before sending to the current output DAC on the IMON pin.  It setting should be computed as follows: "
    textline "                   "
    hexmask.long.byte 0x0 5.--10. 0x1 0x0 " ishr_kp                   ,Current sharing PI filter proportional coefficient index.  Set to 0 to disable the proportional component of the filter.  Note that index settings greater than 55 are clamped to 55. "
    textline "                   "
    hexmask.long.byte 0x0 11.--16. 0x1 0x0 " ishr_ki                   ,Current sharing PI filter integral coefficient index.  Set to 0 to disable the integral component of the filter.  Note that index settings greater than 55 are clamped to 55. "
    textline "                   "
    hexmask.long.byte 0x0 17.--24. 0x1 0x0 " vrect_offset_bck_bst      ,Rectification voltage offset for Buck-Boost topology.  Set to 0 for all other topologies.  When non-zero, the VRS computed Vrect output is modified as follows: "

; ----------------------- ISHARE1 member of common -----------------------

  group 0x0024++0x0003
    line.long 0x000 "ISHARE1, Negative clamp applied to active current sharing voltage adjustment.  This value reflects the voltage at the VSEN input.  To convert to Vout divide by VOUT_SCALE_LOOP."
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " ishare_clamp_neg          ,Negative clamp applied to active current sharing voltage adjustment.  This value reflects the voltage at the VSEN input.  To convert to Vout divide by VOUT_SCALE_LOOP."
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " ishare_clamp_pos          ,Positive clamp applied to active current sharing voltage adjustment.  This value reflects the voltage at the VSEN input.  To convert to Vout divide by VOUT_SCALE_LOOP."

; ---------------------- GPIO_DBEN member of common ----------------------

  group 0x0028++0x0003
    line.long 0x000 "GPIO_DBEN, Spare configuration register space"
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " spare_cfg                 ,Spare configuration register space"
    textline "                   "
    hexmask.long.byte 0x0 16.--23. 0x1 0x0 " gpio0_dben                ,GPIO0 bus input debounce enable "
    textline "                   "
    hexmask.long.byte 0x0 24.--31. 0x1 0x0 " gpio1_dben                ,GPIO1 bus input debounce enable "

; ------------------------ CGATE member of common ------------------------

  group 0x002C++0x0003
    line.long 0x000 "CGATE, HW block clock gating bypassed when bit is high.  In general, since the HW block enables are FW controlled, these bits should all be set to 0. "
    textline "                   "
    hexmask.long.long 0x0 0.--23. 0x1 0x0 " cgate_bypass              ,HW block clock gating bypassed when bit is high.  In general, since the HW block enables are FW controlled, these bits should all be set to 0. "

; ------------------- VSP1_VRS_VRECTE member of common -------------------

  rgroup 0x0030++0x0003
    line.long 0x000 "VSP1_VRS_VRECTE, Measured VS1 (VRSEN) ADC rectification voltage on the even half cycle."
    textline "                   "
    hexmask.long.word 0x0 0.--11. 0x1 0x0 " vsp1_vrs_vrect_even       ,Measured VS1 (VRSEN) ADC rectification voltage on the even half cycle."

; ------------------- VSP1_VRS_VRECTO member of common -------------------

  rgroup 0x0034++0x0003
    line.long 0x000 "VSP1_VRS_VRECTO, Measured VS1 (VRSEN) ADC rectification voltage on the odd half cycle."
    textline "                   "
    hexmask.long.word 0x0 0.--11. 0x1 0x0 " vsp1_vrs_vrect_odd        ,Measured VS1 (VRSEN) ADC rectification voltage on the odd half cycle."

; ----------------- VSP1_VRS_VRECT_AVG member of common -----------------

  rgroup 0x0038++0x0003
    line.long 0x000 "VSP1_VRS_VRECT_AVG, Average of measured VS1 (VRSEN) ADC even and odd half cycle rectification voltages."
    textline "                   "
    hexmask.long.word 0x0 0.--11. 0x1 0x0 " vsp1_vrs_vrect            ,Average of measured VS1 (VRSEN) ADC even and odd half cycle rectification voltages."

; ------------------- VSP2_VRS_VRECTE member of common -------------------

  rgroup 0x003C++0x0003
    line.long 0x000 "VSP2_VRS_VRECTE, Measured VS2 (BVSEN_BVRSEN) ADC rectification voltage on the even half cycle."
    textline "                   "
    hexmask.long.word 0x0 0.--11. 0x1 0x0 " vsp2_vrs_vrect_even       ,Measured VS2 (BVSEN_BVRSEN) ADC rectification voltage on the even half cycle."

; ------------------- VSP2_VRS_VRECTO member of common -------------------

  rgroup 0x0040++0x0003
    line.long 0x000 "VSP2_VRS_VRECTO, Measured VS2 (BVSEN_BVRSEN) ADC rectification voltage on the odd half cycle."
    textline "                   "
    hexmask.long.word 0x0 0.--11. 0x1 0x0 " vsp2_vrs_vrect_odd        ,Measured VS2 (BVSEN_BVRSEN) ADC rectification voltage on the odd half cycle."

; ----------------- VSP2_VRS_VRECT_AVG member of common -----------------

  rgroup 0x0044++0x0003
    line.long 0x000 "VSP2_VRS_VRECT_AVG, Average of measured VS2 (BVSEN_BVRSEN) ADC even and odd half cycle rectification voltages."
    textline "                   "
    hexmask.long.word 0x0 0.--11. 0x1 0x0 " vsp2_vrs_vrect            ,Average of measured VS2 (BVSEN_BVRSEN) ADC even and odd half cycle rectification voltages."

; ----------------------- EN_REG1 member of common -----------------------

  group 0x0048++0x0003
    line.long 0x000 "EN_REG1, FW driven HW block enable for Loop 0 VCONTROL function "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " en_vcontrol0              ,FW driven HW block enable for Loop 0 VCONTROL function "
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " en_vsp0                   ,FW driven HW block enable for VS0 (VSEN) ADC digital processing (VSP) function "
    textline "                   "
    hexmask.long.byte 0x0 2.--2. 0x1 0x0 " en_vs0                    ,FW driven HW block enable for VS0 (VSEN) ADC "
    textline "                   "
    hexmask.long.byte 0x0 3.--3. 0x1 0x0 " en_pid0                   ,FW driven HW block enable for Loop 0 PID function "
    textline "                   "
    hexmask.long.byte 0x0 4.--4. 0x1 0x0 " en_ce0                    ,FW driven HW block enable for CE0 (ISEN) current emulator function "
    textline "                   "
    hexmask.long.byte 0x0 5.--5. 0x1 0x0 " en_is0                    ,FW driven HW block enable for IS1 (ISEN) ADC "
    textline "                   "
    hexmask.long.byte 0x0 6.--6. 0x1 0x0 " en_isp1                   ,FW driven HW block enable for IS1 (ISEN) ADC digital processing (ISP) function "
    textline "                   "
    hexmask.long.byte 0x0 7.--7. 0x1 0x0 " en_telem0                 ,FW driven HW block enable for Loop 0 TELEMETRY function "
    textline "                   "
    hexmask.long.byte 0x0 8.--8. 0x1 0x0 " en_fault0                 ,FW driven HW block enable for Loop 0 FAULT function "
    textline "                   "
    hexmask.long.byte 0x0 9.--9. 0x1 0x0 " en_ramp0                  ,FW driven HW block enable for PWM Ramp 0 "
    textline "                   "
    hexmask.long.byte 0x0 10.--10. 0x1 0x0 " en_pwm0                   ,FW driven HW block enable for Loop 0 PWM function "
    textline "                   "
    hexmask.long.byte 0x0 11.--11. 0x1 0x0 " en_burst0                 ,FW driven, state based HW block enable for Loop 0 Burst Mode function "
    textline "                   "
    hexmask.long.byte 0x0 12.--12. 0x1 0x0 " en_pid_osp0               ,FW driven, state based HW block enable for PID0 open sense protection function "
    textline "                   "
    hexmask.long.byte 0x0 13.--13. 0x1 0x0 " en_vsp1                   ,FW driven HW block enable for VS1 (VRSEN) ADC digital processing (VSP) function "
    textline "                   "
    hexmask.long.byte 0x0 14.--14. 0x1 0x0 " en_vs1                    ,FW driven HW block enable for VS1 (VRSEN) ADC "

; ----------------------- EN_REG2 member of common -----------------------

  group 0x004C++0x0003
    line.long 0x000 "EN_REG2, FW driven HW block enable for Loop 1 VCONTROL function "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " en_vcontrol1              ,FW driven HW block enable for Loop 1 VCONTROL function "
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " en_vsp2                   ,FW driven HW block enable for VS2 (BVSEN_BVRSEN) ADC digital processing (VSP) function "
    textline "                   "
    hexmask.long.byte 0x0 2.--2. 0x1 0x0 " en_vs2                    ,FW driven HW block enable for VS2 (BVSEN_BVRSEN) ADC "
    textline "                   "
    hexmask.long.byte 0x0 3.--3. 0x1 0x0 " en_pid1                   ,FW driven HW block enable for Loop 1 PID function "
    textline "                   "
    hexmask.long.byte 0x0 4.--4. 0x1 0x0 " en_ce1                    ,FW driven HW block enable for CE1 (BISEN) current emulator function "
    textline "                   "
    hexmask.long.byte 0x0 5.--5. 0x1 0x0 " en_is1                    ,FW driven HW block enable for IS3 (BISEN) ADC "
    textline "                   "
    hexmask.long.byte 0x0 6.--6. 0x1 0x0 " en_isp2                   ,FW driven HW block enable for IS3 (BISEN) ADC digital processing (ISP) function "
    textline "                   "
    hexmask.long.byte 0x0 7.--7. 0x1 0x0 " en_telem1                 ,FW driven HW block enable for Loop 1 TELEMETRY function "
    textline "                   "
    hexmask.long.byte 0x0 8.--8. 0x1 0x0 " en_fault1                 ,FW driven HW block enable for Loop 1 FAULT function "
    textline "                   "
    hexmask.long.byte 0x0 9.--9. 0x1 0x0 " en_ramp1                  ,FW driven HW block enable for PWM Ramp 1 "
    textline "                   "
    hexmask.long.byte 0x0 10.--10. 0x1 0x0 " en_pwm1                   ,FW driven HW block enable for Loop 1 PWM function "
    textline "                   "
    hexmask.long.byte 0x0 11.--11. 0x1 0x0 " en_burst1                 ,FW driven, state based HW block enable for Loop 1 Burst Mode function "
    textline "                   "
    hexmask.long.byte 0x0 12.--12. 0x1 0x0 " en_pid_osp1               ,FW driven, state based HW block enable for PID1 open sense protection function "

; ----------------------- EN_REG3 member of common -----------------------

  group 0x0050++0x0003
    line.long 0x000 "EN_REG3, FW driven HW block enable for TS ADC "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " en_tsen                   ,FW driven HW block enable for TS ADC "
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " en_sync                   ,FW driven HW block enable for SYNC function "
    textline "                   "
    hexmask.long.byte 0x0 2.--2. 0x1 0x0 " en_ibal                   ,FW driven HW block enable for Current Balance function "
    textline "                   "
    hexmask.long.byte 0x0 3.--3. 0x1 0x0 " en_fbal                   ,FW driven HW block enable for Loop 0 Flux / Voltage Balance function  Flux balance only functional when corresponding rampX_dutyc_lock also enabled."
    textline "                   "
    hexmask.long.byte 0x0 4.--4. 0x1 0x0 " en_tsp                    ,Not used"
    textline "                   "
    hexmask.long.byte 0x0 5.--5. 0x1 0x0 " en_ts                     ,Not used"
    textline "                   "
    hexmask.long.byte 0x0 6.--6. 0x1 0x0 " en_telemc                 ,FW driven HW block enable for Common TELEMETRY functions (ATSEN, BTSEN, etc.) "
    textline "                   "
    hexmask.long.byte 0x0 7.--7. 0x1 0x0 " en_faultc                 ,FW driven HW block enable for Common FAULT functions "
    textline "                   "
    hexmask.long.byte 0x0 9.--9. 0x1 0x0 " en_fan1                   ,FW driven HW block enable for FAN1 function "
    textline "                   "
    hexmask.long.byte 0x0 10.--10. 0x1 0x0 " en_fan2                   ,FW driven HW block enable for FAN2 function "
    textline "                   "
    hexmask.long.byte 0x0 11.--11. 0x1 0x0 " en_fbal2                  ,FW driven HW block enable for Loop 1 Flux / Voltage Balance function "
    textline "                   "
    hexmask.long.byte 0x0 12.--12. 0x1 0x0 " en_ishare                 ,FW driven HW block enable for IMON based current sharing function "

; --------------------- FPGA_STATUS member of common ---------------------

  rgroup 0x0054++0x0003
    line.long 0x000 "FPGA_STATUS, FPGA Status register.  See bitfile release notes for description."
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " fpga_status               ,FPGA Status register.  See bitfile release notes for description."

; --------------------- FPGA_CONFIG member of common ---------------------

  group 0x0058++0x0003
    line.long 0x000 "FPGA_CONFIG, FPGA Configuration Register: "
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " fpga_config               ,FPGA Configuration Register: "

; --------------------- VSP1_SR_CNT member of common ---------------------

  rgroup 0x005C++0x0003
    line.long 0x000 "VSP1_SR_CNT, Block averaged VRS1 SR FET falling edge to VRS Comp rising edge measurement result."
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " vsp1_cnt_srf_avg          ,Block averaged VRS1 SR FET falling edge to VRS Comp rising edge measurement result."
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " vsp1_cnt_srr_avg          ,Block averaged VRS1 VRS Comp falling edge to SR FET rising edge measurement result."
    textline "                   "
    hexmask.long.byte 0x0 16.--23. 0x1 0x0 " vsp1_cnt_srf2vrsr         ,Non-averaged VRS1 SR FET falling edge to VRS Comp rising edge measurement result."
    textline "                   "
    hexmask.long.byte 0x0 24.--31. 0x1 0x0 " vsp1_cnt_vrsf2srr         ,Non-averaged VRS1 VRS Comp falling edge to SR FET rising edge measurement result."

; -------------------- VSP1_VRS_CNT member of common --------------------

  rgroup 0x0060++0x0003
    line.long 0x000 "VSP1_VRS_CNT, Non-averaged VRS1 VRS Comp pulse width measurement result for ACF topology or the even half cycle of bridge topologies."
    textline "                   "
    hexmask.long.word 0x0 0.--10. 0x1 0x0 " vsp1_cnt_vrscomp_e        ,Non-averaged VRS1 VRS Comp pulse width measurement result for ACF topology or the even half cycle of bridge topologies."
    textline "                   "
    hexmask.long.word 0x0 11.--21. 0x1 0x0 " vsp1_cnt_vrscomp_o        ,Non-averaged VRS1 VRS Comp pulse width measurement result for the odd half cycle of bridge topologies."
    textline "                   "
    hexmask.long.byte 0x0 22.--22. 0x1 0x0 " vsp1_srr_b4_vrsf          ,Status flag indicating VRS1 detected SR FET rising edge before VRS Comp falling edge (i.e., no dead time on PWM falling edge) on previous cycle. "
    textline "                   "
    hexmask.long.byte 0x0 23.--23. 0x1 0x0 " vsp1_vrsr_b4_srf          ,Status flag indicating VRS1 detected VRS Comp rising edge before SR FET falling edge (i.e., no dead time on PWM rising edge) on previous cycle. "

; --------------------- VSP2_SR_CNT member of common ---------------------

  rgroup 0x0064++0x0003
    line.long 0x000 "VSP2_SR_CNT, Block averaged VRS2 SR FET falling edge to VRS Comp rising edge measurement result."
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " vsp2_cnt_srf_avg          ,Block averaged VRS2 SR FET falling edge to VRS Comp rising edge measurement result."
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " vsp2_cnt_srr_avg          ,Block averaged VRS2 VRS Comp falling edge to SR FET rising edge measurement result."
    textline "                   "
    hexmask.long.byte 0x0 16.--23. 0x1 0x0 " vsp2_cnt_srf2vrsr         ,Non-averaged VRS2 SR FET falling edge to VRS Comp rising edge measurement result."
    textline "                   "
    hexmask.long.byte 0x0 24.--31. 0x1 0x0 " vsp2_cnt_vrsf2srr         ,Non-averaged VRS2 VRS Comp falling edge to SR FET rising edge measurement result."

; -------------------- VSP2_VRS_CNT member of common --------------------

  rgroup 0x0068++0x0003
    line.long 0x000 "VSP2_VRS_CNT, Non-averaged VRS2 VRS Comp pulse width measurement result for ACF topology or the even half cycle of bridge topologies."
    textline "                   "
    hexmask.long.word 0x0 0.--10. 0x1 0x0 " vsp2_cnt_vrscomp_e        ,Non-averaged VRS2 VRS Comp pulse width measurement result for ACF topology or the even half cycle of bridge topologies."
    textline "                   "
    hexmask.long.word 0x0 11.--21. 0x1 0x0 " vsp2_cnt_vrscomp_o        ,Non-averaged VRS1 VRS Comp pulse width measurement result for the odd half cycle of bridge topologies."
    textline "                   "
    hexmask.long.byte 0x0 22.--22. 0x1 0x0 " vsp2_srr_b4_vrsf          ,Status flag indicating VRS2 detected SR FET rising edge before VRS Comp falling edge (i.e., no dead time on PWM falling edge) on previous cycle. "
    textline "                   "
    hexmask.long.byte 0x0 23.--23. 0x1 0x0 " vsp2_vrsr_b4_srf          ,Status flag indicating VRS2 detected VRS Comp rising edge before SR FET falling edge (i.e., no dead time on PWM rising edge) on previous cycle. "

; ---------------------- FSW_IRQ0 member of common ----------------------

  group 0x006C++0x0003
    line.long 0x000 "FSW_IRQ0, Defines the Fswitch based interrupt rate in number of switching periods, tswitch0.  Bit [3] controls when the IRQ's occur.  If 0, IRQ's only occur in active regulation (vc0_vramp_on=1), otherwise IRQ's are continuous and independent of regulation. "
    textline "                   "
    hexmask.long.byte 0x0 0.--3. 0x1 0x0 " fsw0_irq0_sel             ,Defines the Fswitch based interrupt rate in number of switching periods, tswitch0.  Bit [3] controls when the IRQ's occur.  If 0, IRQ's only occur in active regulation (vc0_vramp_on=1), otherwise IRQ's are continuous and independent of regulation. "
    textline "                   "
    hexmask.long.byte 0x0 4.--7. 0x1 0x0 " fsw0_irq1_sel             ,Defines the Fswitch based interrupt rate in number of switching periods, tswitch0.  Bit [3] controls when the IRQ's occur.  If 0, IRQ's only occur in active regulation (vc0_vramp_on=1), otherwise IRQ's are continuous and independent of regulation. "
    textline "                   "
    hexmask.long.byte 0x0 8.--11. 0x1 0x0 " fsw0_irq2_sel             ,Defines the Fswitch based interrupt rate in number of switching periods, tswitch0.  Bit [3] controls when the IRQ's occur.  If 0, IRQ's only occur in active regulation (vc0_vramp_on=1), otherwise IRQ's are continuous and independent of regulation. "
    textline "                   "
    hexmask.long.byte 0x0 12.--15. 0x1 0x0 " fsw0_irq3_sel             ,Defines the Fswitch based interrupt rate in number of switching periods, tswitch0.  Bit [3] controls when the IRQ's occur.  If 0, IRQ's only occur in active regulation (vc0_vramp_on=1), otherwise IRQ's are continuous and independent of regulation. "
    textline "                   "
    hexmask.long.byte 0x0 16.--19. 0x1 0x0 " fsw0_irq4_sel             ,Defines the Fswitch based interrupt rate in number of switching periods, tswitch0.  Bit [3] controls when the IRQ's occur.  If 0, IRQ's only occur in active regulation (vc0_vramp_on=1), otherwise IRQ's are continuous and independent of regulation. "
    textline "                   "
    hexmask.long.byte 0x0 20.--23. 0x1 0x0 " fsw0_irq5_sel             ,Defines the Fswitch based interrupt rate in number of switching periods, tswitch0.  Bit [3] controls when the IRQ's occur.  If 0, IRQ's only occur in active regulation (vc0_vramp_on=1), otherwise IRQ's are continuous and independent of regulation. "
    textline "                   "
    hexmask.long.byte 0x0 24.--27. 0x1 0x0 " fsw0_irq6_sel             ,Defines the Fswitch based interrupt rate in number of switching periods, tswitch0.  Bit [3] controls when the IRQ's occur.  If 0, IRQ's only occur in active regulation (vc0_vramp_on=1), otherwise IRQ's are continuous and independent of regulation. "
    textline "                   "
    hexmask.long.byte 0x0 28.--31. 0x1 0x0 " fsw0_irq7_sel             ,Defines the Fswitch based interrupt rate in number of switching periods, tswitch0.  Bit [3] controls when the IRQ's occur.  If 0, IRQ's only occur in active regulation (vc0_vramp_on=1), otherwise IRQ's are continuous and independent of regulation. "

; ---------------------- FSW_IRQ1 member of common ----------------------

  group 0x0070++0x0003
    line.long 0x000 "FSW_IRQ1, Defines the Fswitch based interrupt rate in number of switching periods, tswitch1.  Bit [3] controls when the IRQ's occur.  If 0, IRQ's only occur in active regulation (vc1_vramp_on=1), otherwise IRQ's are continuous and independent of regulation. "
    textline "                   "
    hexmask.long.byte 0x0 0.--3. 0x1 0x0 " fsw1_irq0_sel             ,Defines the Fswitch based interrupt rate in number of switching periods, tswitch1.  Bit [3] controls when the IRQ's occur.  If 0, IRQ's only occur in active regulation (vc1_vramp_on=1), otherwise IRQ's are continuous and independent of regulation. "
    textline "                   "
    hexmask.long.byte 0x0 4.--7. 0x1 0x0 " fsw1_irq1_sel             ,Defines the Fswitch based interrupt rate in number of switching periods, tswitch1.  Bit [3] controls when the IRQ's occur.  If 0, IRQ's only occur in active regulation (vc1_vramp_on=1), otherwise IRQ's are continuous and independent of regulation. "
    textline "                   "
    hexmask.long.byte 0x0 8.--11. 0x1 0x0 " fsw1_irq2_sel             ,Defines the Fswitch based interrupt rate in number of switching periods, tswitch1.  Bit [3] controls when the IRQ's occur.  If 0, IRQ's only occur in active regulation (vc1_vramp_on=1), otherwise IRQ's are continuous and independent of regulation. "
    textline "                   "
    hexmask.long.byte 0x0 12.--15. 0x1 0x0 " fsw1_irq3_sel             ,Defines the Fswitch based interrupt rate in number of switching periods, tswitch1.  Bit [3] controls when the IRQ's occur.  If 0, IRQ's only occur in active regulation (vc1_vramp_on=1), otherwise IRQ's are continuous and independent of regulation. "
    textline "                   "
    hexmask.long.byte 0x0 16.--19. 0x1 0x0 " fsw1_irq4_sel             ,Defines the Fswitch based interrupt rate in number of switching periods, tswitch1.  Bit [3] controls when the IRQ's occur.  If 0, IRQ's only occur in active regulation (vc1_vramp_on=1), otherwise IRQ's are continuous and independent of regulation. "
    textline "                   "
    hexmask.long.byte 0x0 20.--23. 0x1 0x0 " fsw1_irq5_sel             ,Defines the Fswitch based interrupt rate in number of switching periods, tswitch1.  Bit [3] controls when the IRQ's occur.  If 0, IRQ's only occur in active regulation (vc1_vramp_on=1), otherwise IRQ's are continuous and independent of regulation. "
    textline "                   "
    hexmask.long.byte 0x0 24.--27. 0x1 0x0 " fsw1_irq6_sel             ,Defines the Fswitch based interrupt rate in number of switching periods, tswitch1.  Bit [3] controls when the IRQ's occur.  If 0, IRQ's only occur in active regulation (vc1_vramp_on=1), otherwise IRQ's are continuous and independent of regulation. "
    textline "                   "
    hexmask.long.byte 0x0 28.--31. 0x1 0x0 " fsw1_irq7_sel             ,Defines the Fswitch based interrupt rate in number of switching periods, tswitch1.  Bit [3] controls when the IRQ's occur.  If 0, IRQ's only occur in active regulation (vc1_vramp_on=1), otherwise IRQ's are continuous and independent of regulation. "

; ----------------------- IBAL_FW member of common -----------------------

  group 0x0074++0x0003
    line.long 0x000 "IBAL_FW, When ibal_fw_en is high, this register overrides the HW current balance duty cycle adjust output with a FW controlled setting."
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " ibal_fw_adj               ,When ibal_fw_en is high, this register overrides the HW current balance duty cycle adjust output with a FW controlled setting."
    textline "                   "
    hexmask.long.byte 0x0 8.--8. 0x1 0x0 " ibal_fw_en                ,Enables FW controlled current balance loop via ibal_fw_adj. "

; ---------------------- FBAL1_FW member of common ----------------------

  group 0x0078++0x0003
    line.long 0x000 "FBAL1_FW, When fbal1_fw_en is high, this register overrides the Loop 0, Phase 1 HW flux / voltage balance duty cycle adjust output with a FW controlled setting."
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " fbal1_fw_adj              ,When fbal1_fw_en is high, this register overrides the Loop 0, Phase 1 HW flux / voltage balance duty cycle adjust output with a FW controlled setting."
    textline "                   "
    hexmask.long.byte 0x0 8.--8. 0x1 0x0 " fbal1_fw_en               ,Enables FW controlled flux / voltage balance loop via fbal1_fw_adj. "

; ---------------------- FBAL2_FW member of common ----------------------

  group 0x007C++0x0003
    line.long 0x000 "FBAL2_FW, When fbal2_fw_en is high, this register overrides the Loop 0, Phase 2 or Loop 1 HW flux / voltage balance duty cycle adjust output with a FW controlled setting."
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " fbal2_fw_adj              ,When fbal2_fw_en is high, this register overrides the Loop 0, Phase 2 or Loop 1 HW flux / voltage balance duty cycle adjust output with a FW controlled setting."
    textline "                   "
    hexmask.long.byte 0x0 8.--8. 0x1 0x0 " fbal2_fw_en               ,Enables FW controlled flux / voltage balance loop via fbal2_fw_adj. "

; ---------------------- ISHARE_FW member of common ----------------------

  group 0x0080++0x0003
    line.long 0x000 "ISHARE_FW, When ishr_fw_en is high, this register overrides the HW current share voltage adjust output with a FW controlled setting."
    textline "                   "
    hexmask.long.word 0x0 0.--11. 0x1 0x0 " ishr_fw_adj               ,When ishr_fw_en is high, this register overrides the HW current share voltage adjust output with a FW controlled setting."
    textline "                   "
    hexmask.long.byte 0x0 12.--12. 0x1 0x0 " ishr_fw_en                ,Enables FW controlled current share loop via ishr_fw_adj. "

; ----------------------- IDAC_FW member of common -----------------------

  group 0x0084++0x0003
    line.long 0x000 "IDAC_FW, When idac_fw_en is high, this register overrides the HW current DAC output with a FW controlled setting."
    textline "                   "
    hexmask.long.word 0x0 0.--9. 0x1 0x0 " idac_fw_frc               ,When idac_fw_en is high, this register overrides the HW current DAC output with a FW controlled setting."
    textline "                   "
    hexmask.long.byte 0x0 10.--10. 0x1 0x0 " idac_fw_en                ,Enables FW controlled current DAC output via idac_fw_adj. "

; ----------------------- XADDR1 member of common -----------------------

  group 0x0088++0x0003
    line.long 0x000 "XADDR1, XADDR1 weak pulldown control "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " xaddr1_pd                 ,XADDR1 weak pulldown control "

; ------------------------ IO_IN member of common ------------------------

  rgroup 0x008C++0x0003
    line.long 0x000 "IO_IN, IO inputs for test.  Only active when force_all_in=1. "
    textline "                   "
    hexmask.long.long 0x0 0.--23. 0x1 0x0 " io_inputs                 ,IO inputs for test.  Only active when force_all_in=1. "

; --------------------- CE0_IOFFSET member of common ---------------------

  rgroup 0x0090++0x0003
    line.long 0x000 "CE0_IOFFSET, CE0 / IS1 calibrated offset status register."
    textline "                   "
    hexmask.long.word 0x0 0.--12. 0x1 0x0 " ce0_ioffset               ,CE0 / IS1 calibrated offset status register."

; --------------------- CE1_IOFFSET member of common ---------------------

  rgroup 0x0094++0x0003
    line.long 0x000 "CE1_IOFFSET, CE1 / IS2 calibrated offset status register."
    textline "                   "
    hexmask.long.word 0x0 0.--12. 0x1 0x0 " ce1_ioffset               ,CE1 / IS2 calibrated offset status register."

; --------------------- CE2_IOFFSET member of common ---------------------

  rgroup 0x0098++0x0003
    line.long 0x000 "CE2_IOFFSET, CE2 / IS3 calibrated offset status register."
    textline "                   "
    hexmask.long.word 0x0 0.--12. 0x1 0x0 " ce2_ioffset               ,CE2 / IS3 calibrated offset status register."

; ---------------------- ISHARE_DZ member of common ----------------------

  group 0x009C++0x0003
    line.long 0x000 "ISHARE_DZ, Ishare dead zone below which current sharing is not attempted. To convert to Amps divide by ishr_scale."
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " ishare_dead_zone          ,Ishare dead zone below which current sharing is not attempted. To convert to Amps divide by ishr_scale."

; ---------------------- LO_SLEEP member of common ----------------------

  group 0x00A0++0x0003
    line.long 0x000 "LO_SLEEP, Not used"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " lo_sleep_mode             ,Not used"

; ---------------------- DIG_SYNC member of common ----------------------

  rgroup 0x00A4++0x0003
    line.long 0x000 "DIG_SYNC, Current SYNC flywheel period, will match incoming period when lock achieved."
    textline "                   "
    hexmask.long.word 0x0 0.--10. 0x1 0x0 " sync_fly_period           ,Current SYNC flywheel period, will match incoming period when lock achieved."
    textline "                   "
    hexmask.long.word 0x0 11.--21. 0x1 0x0 " sync_in_period            ,Measured incoming period on SYNC input."
    textline "                   "
    hexmask.long.byte 0x0 22.--23. 0x1 0x0 " sync_state                ,Digital SYNC state "
    textline "                   "
    hexmask.long.byte 0x0 24.--24. 0x1 0x0 " sync_in_range             ,Digital SYNC  in range  status.  The SYNC input can make initial lock to an incoming signal within +/-6.25% of the internal clock frequency.  Once locked, the SYNC function can maintain lock within a +/-12.5% deviation of the internal clock frequency. "

; ---------------------- VDAC_CFG member of common ----------------------

  group 0x00A8++0x0003
    line.long 0x000 "VDAC_CFG, Offset added to Voltage DAC 16-bit input word."
    textline "                   "
    hexmask.long.word 0x0 0.--14. 0x1 0x0 " vdac_offset               ,Offset added to Voltage DAC 16-bit input word."
    textline "                   "
    hexmask.long.byte 0x0 15.--18. 0x1 0x0 " vdac_shift                ,Left shift applied to Voltage DAC 16-bit input word after application of vdac_mask but before any other operations.  During the shift, right-side bits are filled with 0's.  Note that ultimately only the upper 8 bits of the 16-bit word are used to control the DAC output."

; ----------------------- VDAC_EN member of common -----------------------

  group 0x00AC++0x0003
    line.long 0x000 "VDAC_EN, Voltage DAC analog block enable "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " vdac_en                   ,Voltage DAC analog block enable "
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " vdac_neg_ignore           ,Voltage DAC negative input clamp enable.  Applied to shifted data word. "
    textline "                   "
    hexmask.long.byte 0x0 2.--2. 0x1 0x0 " vdac_in_unsigned          ,Voltage DAC input word format "
    textline "                   "
    hexmask.long.byte 0x0 3.--3. 0x1 0x0 " vdac_out_sign             ,Voltage DAC output word format "

; ---------------------- VDAC_MASK member of common ----------------------

  group 0x00B0++0x0003
    line.long 0x000 "VDAC_MASK, Active high mask applied to the Voltage DAC 16-bit input word to zero out selected bits.  Applied as, "
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " vdac_mask                 ,Active high mask applied to the Voltage DAC 16-bit input word to zero out selected bits.  Applied as, "

; ---------------------- VDAC_DIG member of common ----------------------

  rgroup 0x00B4++0x0003
    line.long 0x000 "VDAC_DIG, Voltage DAC output word."
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " vdac_dig                  ,Voltage DAC output word."

; ---------------------- FW_RESET member of common ----------------------

  group 0x00B8++0x0003
    line.long 0x000 "FW_RESET, Controller reset.  Setting this register high initiates the equivalent of a power on reset to all controller functions except the CPU debugger access port when the debugger port has been enabled via the XADDR1 pin at powerup. "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " fw_reset                  ,Controller reset.  Setting this register high initiates the equivalent of a power on reset to all controller functions except the CPU debugger access port when the debugger port has been enabled via the XADDR1 pin at powerup. "

; --------------------- FSW_IRQ_CLR member of common ---------------------

  group 0x00BC++0x0003
    line.long 0x000 "FSW_IRQ_CLR, FSW0_IRQ CLEAR "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " fsw0_irq_clr              ,FSW0_IRQ CLEAR "
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " fsw1_irq_clr              ,FSW1_IRQ CLEAR "

; ---------------------- FSW_STAT member of common ----------------------

  rgroup 0x00C0++0x0003
    line.long 0x000 "FSW_STAT, FSW0_IRQ STATUS "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " fsw0_status               ,FSW0_IRQ STATUS "
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " fsw1_status               ,FSW1_IRQ STATUS "

; --------------------- FBAL_THRESH member of common ---------------------

  group 0x00C4++0x0003
    line.long 0x000 "FBAL_THRESH, flux balance fault threshold - TBD (0=disable) format and default values need to be updated  for simplicity  - currently set to U8.0 and will be updated once this fault is further defined"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " flux_bal_thresh           ,flux balance fault threshold - TBD (0=disable) format and default values need to be updated  for simplicity  - currently set to U8.0 and will be updated once this fault is further defined"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " fbal_integ_thresh         ,flux balance integrator error threshold defined with respect to max integrator range. "
    textline "                   "
    hexmask.long.byte 0x0 10.--12. 0x1 0x0 " fbal_lpf_kpshift          ,Coefficient of LPF at output of fbal error, set to 0 to bypass Kp = 2^-Kpshift F3db = [kp/(1-kp)] * 50MHz / 2pi"
    textline "                   "
    hexmask.long.byte 0x0 13.--13. 0x1 0x0 " fbal_delta_abs_en         ,determines whether absoulte values to be applied to the error input before or after the low pass_filter "

tree.end

; -------------------------------------------------------------------
; End Block - common
; -------------------------------------------------------------------
tree.end
; @file:      crc32.per
; Chip name:  SHASTA
; Module:     crc32
; 
; Generated by the pmm metagen library.
;
; ===================================================================
; Copyright (C) 2018 Infineon Technologies AG
; All rights reserved.
; ===================================================================
;
; ===================================================================
; This document contains proprietary information. Passing on and
; copying of this document, and communication of its contents is not
; permitted without prior written authorisation.
; ===================================================================

; This file is automatically generated. Do not edit!


config 32. 8.
width 20.

tree "Block - crc32"
; -------------------------------------------------------------------
; Begin Block - crc32
; -------------------------------------------------------------------
base D:0x70090000

tree "crc32"
; ------------------------- DATA member of crc32 -------------------------

  group 0x0000++0x0003
    line.long 0x000 "DATA, CRC DATA IN & OUT register"
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " VAL                       ,"

; ------------------------- INIT member of crc32 -------------------------

  group 0x0004++0x0003
    line.long 0x000 "INIT, CRC Initialization Value register"
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " VAL                       ,"

; ------------------------- POLY member of crc32 -------------------------

  group 0x0008++0x0003
    line.long 0x000 "POLY, CRC Polynomial Configuration Register"
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " VAL                       ,"

; ------------------------- XORE member of crc32 -------------------------

  group 0x000C++0x0003
    line.long 0x000 "XORE, CRC Final XOR Configuration Register"
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " VAL                       ,"

; ------------------------- CNFG member of crc32 -------------------------

  group 0x0010++0x0003
    line.long 0x000 "CNFG, CRC Control Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " REFIN                     ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " REFOUT                    ,"

tree.end

; -------------------------------------------------------------------
; End Block - crc32
; -------------------------------------------------------------------
tree.end
; @file:      cse.per
; Chip name:  SHASTA
; Module:     cse
; 
; Generated by the pmm metagen library.
;
; ===================================================================
; Copyright (C) 2018 Infineon Technologies AG
; All rights reserved.
; ===================================================================
;
; ===================================================================
; This document contains proprietary information. Passing on and
; copying of this document, and communication of its contents is not
; permitted without prior written authorisation.
; ===================================================================

; This file is automatically generated. Do not edit!


config 32. 8.
width 20.

tree "Block - cse"
; -------------------------------------------------------------------
; Begin Block - cse
; -------------------------------------------------------------------
base D:0x70006000

tree "cse"
; -------------------------- CSE1 member of cse --------------------------

  group 0x0000++0x0003
    line.long 0x000 "CSE1, Loop 0 non-linear (cubic) droop based on IOUT^3, LSB = 2^-16 * 1.25 mV/A^3, Range = 0.0 to 2^-16 * 318.75 mV/A^3"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " vc0_vavp_rll_nl           ,Loop 0 non-linear (cubic) droop based on IOUT^3, LSB = 2^-16 * 1.25 mV/A^3, Range = 0.0 to 2^-16 * 318.75 mV/A^3"

; -------------------------- CSE2 member of cse --------------------------

  group 0x0004++0x0003
    line.long 0x000 "CSE2, Loop 1 non-linear (cubic) droop based on IOUT^3, LSB = 2^-16 * 1.25 mV/A^3, Range = 0.0 to 2^-16 * 318.75 mV/A^3"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " vc1_vavp_rll_nl           ,Loop 1 non-linear (cubic) droop based on IOUT^3, LSB = 2^-16 * 1.25 mV/A^3, Range = 0.0 to 2^-16 * 318.75 mV/A^3"

tree.end

; -------------------------------------------------------------------
; End Block - cse
; -------------------------------------------------------------------
tree.end
; @file:      debug.per
; Chip name:  SHASTA
; Module:     debug
; 
; Generated by the pmm metagen library.
;
; ===================================================================
; Copyright (C) 2018 Infineon Technologies AG
; All rights reserved.
; ===================================================================
;
; ===================================================================
; This document contains proprietary information. Passing on and
; copying of this document, and communication of its contents is not
; permitted without prior written authorisation.
; ===================================================================

; This file is automatically generated. Do not edit!


config 32. 8.
width 20.

tree "Block - debug"
; -------------------------------------------------------------------
; Begin Block - debug
; -------------------------------------------------------------------
base D:0x40003000

tree "debug"
; ----------------------- DATA_LUT member of debug -----------------------

  group 0x0000++0x0003
    line.long 0x000 "DATA_LUT #0, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA0                     ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " DATA1                     ,"
    textline "                   "
    hexmask.long.byte 0x0 16.--23. 0x1 0x0 " DATA2                     ,"
    textline "                   "
    hexmask.long.byte 0x0 24.--31. 0x1 0x0 " DATA3                     ,"

  group 0x0004++0x0003
    line.long 0x000 "DATA_LUT #1, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA0                     ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " DATA1                     ,"
    textline "                   "
    hexmask.long.byte 0x0 16.--23. 0x1 0x0 " DATA2                     ,"
    textline "                   "
    hexmask.long.byte 0x0 24.--31. 0x1 0x0 " DATA3                     ,"

  group 0x0008++0x0003
    line.long 0x000 "DATA_LUT #2, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA0                     ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " DATA1                     ,"
    textline "                   "
    hexmask.long.byte 0x0 16.--23. 0x1 0x0 " DATA2                     ,"
    textline "                   "
    hexmask.long.byte 0x0 24.--31. 0x1 0x0 " DATA3                     ,"

  group 0x000C++0x0003
    line.long 0x000 "DATA_LUT #3, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA0                     ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " DATA1                     ,"
    textline "                   "
    hexmask.long.byte 0x0 16.--23. 0x1 0x0 " DATA2                     ,"
    textline "                   "
    hexmask.long.byte 0x0 24.--31. 0x1 0x0 " DATA3                     ,"

  group 0x0010++0x0003
    line.long 0x000 "DATA_LUT #4, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA0                     ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " DATA1                     ,"
    textline "                   "
    hexmask.long.byte 0x0 16.--23. 0x1 0x0 " DATA2                     ,"
    textline "                   "
    hexmask.long.byte 0x0 24.--31. 0x1 0x0 " DATA3                     ,"

  group 0x0014++0x0003
    line.long 0x000 "DATA_LUT #5, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA0                     ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " DATA1                     ,"
    textline "                   "
    hexmask.long.byte 0x0 16.--23. 0x1 0x0 " DATA2                     ,"
    textline "                   "
    hexmask.long.byte 0x0 24.--31. 0x1 0x0 " DATA3                     ,"

  group 0x0018++0x0003
    line.long 0x000 "DATA_LUT #6, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA0                     ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " DATA1                     ,"
    textline "                   "
    hexmask.long.byte 0x0 16.--23. 0x1 0x0 " DATA2                     ,"
    textline "                   "
    hexmask.long.byte 0x0 24.--31. 0x1 0x0 " DATA3                     ,"

  group 0x001C++0x0003
    line.long 0x000 "DATA_LUT #7, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA0                     ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " DATA1                     ,"
    textline "                   "
    hexmask.long.byte 0x0 16.--23. 0x1 0x0 " DATA2                     ,"
    textline "                   "
    hexmask.long.byte 0x0 24.--31. 0x1 0x0 " DATA3                     ,"

  group 0x0020++0x0003
    line.long 0x000 "DATA_LUT #8, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA0                     ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " DATA1                     ,"
    textline "                   "
    hexmask.long.byte 0x0 16.--23. 0x1 0x0 " DATA2                     ,"
    textline "                   "
    hexmask.long.byte 0x0 24.--31. 0x1 0x0 " DATA3                     ,"

  group 0x0024++0x0003
    line.long 0x000 "DATA_LUT #9, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA0                     ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " DATA1                     ,"
    textline "                   "
    hexmask.long.byte 0x0 16.--23. 0x1 0x0 " DATA2                     ,"
    textline "                   "
    hexmask.long.byte 0x0 24.--31. 0x1 0x0 " DATA3                     ,"

  group 0x0028++0x0003
    line.long 0x000 "DATA_LUT #10, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA0                     ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " DATA1                     ,"
    textline "                   "
    hexmask.long.byte 0x0 16.--23. 0x1 0x0 " DATA2                     ,"
    textline "                   "
    hexmask.long.byte 0x0 24.--31. 0x1 0x0 " DATA3                     ,"

  group 0x002C++0x0003
    line.long 0x000 "DATA_LUT #11, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA0                     ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " DATA1                     ,"
    textline "                   "
    hexmask.long.byte 0x0 16.--23. 0x1 0x0 " DATA2                     ,"
    textline "                   "
    hexmask.long.byte 0x0 24.--31. 0x1 0x0 " DATA3                     ,"

  group 0x0030++0x0003
    line.long 0x000 "DATA_LUT #12, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA0                     ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " DATA1                     ,"
    textline "                   "
    hexmask.long.byte 0x0 16.--23. 0x1 0x0 " DATA2                     ,"
    textline "                   "
    hexmask.long.byte 0x0 24.--31. 0x1 0x0 " DATA3                     ,"

  group 0x0034++0x0003
    line.long 0x000 "DATA_LUT #13, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA0                     ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " DATA1                     ,"
    textline "                   "
    hexmask.long.byte 0x0 16.--23. 0x1 0x0 " DATA2                     ,"
    textline "                   "
    hexmask.long.byte 0x0 24.--31. 0x1 0x0 " DATA3                     ,"

  group 0x0038++0x0003
    line.long 0x000 "DATA_LUT #14, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA0                     ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " DATA1                     ,"
    textline "                   "
    hexmask.long.byte 0x0 16.--23. 0x1 0x0 " DATA2                     ,"
    textline "                   "
    hexmask.long.byte 0x0 24.--31. 0x1 0x0 " DATA3                     ,"

  group 0x003C++0x0003
    line.long 0x000 "DATA_LUT #15, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA0                     ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " DATA1                     ,"
    textline "                   "
    hexmask.long.byte 0x0 16.--23. 0x1 0x0 " DATA2                     ,"
    textline "                   "
    hexmask.long.byte 0x0 24.--31. 0x1 0x0 " DATA3                     ,"

tree.end

; -------------------------------------------------------------------
; End Block - debug
; -------------------------------------------------------------------
tree.end
; @file:      dma_sh.per
; Chip name:  SHASTA
; Module:     dma_sh
; 
; Generated by the pmm metagen library.
;
; ===================================================================
; Copyright (C) 2018 Infineon Technologies AG
; All rights reserved.
; ===================================================================
;
; ===================================================================
; This document contains proprietary information. Passing on and
; copying of this document, and communication of its contents is not
; permitted without prior written authorisation.
; ===================================================================

; This file is automatically generated. Do not edit!


config 32. 8.
width 20.

tree "Block - dma_sh"
; -------------------------------------------------------------------
; Begin Block - dma_sh
; -------------------------------------------------------------------
base D:0x50000000

tree "dma"
; --------------------- DMA_STATUS member of dma_sh ---------------------

  rgroup 0x0000++0x0003
    line.long 0x000 "DMA_STATUS, DMA Status"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " MASTER_ENABLE             ,Enable Status of the Controller"
    textline "                   "
    bitfld.long 0x0 4.--7. " STATE                     ,Current State of the Control State Machine" "IDLE (0),READING_CH_CONTROLLER_DATA (1),READING_CH_SRC_DATA_EP (2),READING_CH_DEST_DATA_EP (3),READING_SRC_DATA (4),WRITING_DEST_DATA (5),WRITING_FOR_DMA_REQ_TO_CLR (6),WRITING_CHANNEL_CONTROLLER_DATA (7),STALLED (8),DONE (9),PERIPHERAL_SCATTER_GATHER_TRANSITION (a),%x..."
    textline "                   "
    hexmask.long.byte 0x0 16.--20. 0x1 0x0 " CHNLS_MINUS1              ,Available Channels minus 1"

; ----------------------- DMA_CFG member of dma_sh -----------------------

  group 0x0004++0x0003
    line.long 0x000 "DMA_CFG, DMA Configuration"
    textline "                   "
    bitfld.long 0x0 0. " MASTER_ENABLE             ,Enable for the Controller" "DS (0),EN (1)"
    textline "                   "
    hexmask.long.byte 0x0 5.--7. 0x1 0x0 " CHN1_PROT_CTRL            ,CHN1_PROT_CTRL"

; ------------------ DMA_CTRL_BASE_PTR member of dma_sh ------------------

  group 0x0008++0x0003
    line.long 0x000 "DMA_CTRL_BASE_PTR, Channel Control Data Base Pointer"
    textline "                   "
    hexmask.long.long 0x0 9.--31. 0x1 0x0 " CTRL_BASE_PTR             ,CTRL_BASE_PTR"

; ---------------- DMA_ALT_CTRL_BASE_PTR member of dma_sh ----------------

  rgroup 0x000C++0x0003
    line.long 0x000 "DMA_ALT_CTRL_BASE_?, Channel Alternate Control Data Base Pointer"
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " ALT_CTRL_BASE_PTR         ,Base Address of the Alternate Data Structure"

; ---------------- CHNL_WAITONREQ_STATUS member of dma_sh ----------------

  rgroup 0x0010++0x0003
    line.long 0x000 "CHNL_WAITONREQ_STA?, Channel Wait on Request Status"
    textline "                   "
    bitfld.long 0x0 0.--15. " DMA_WAITONREQ_STATUS      ,Channel Wait on Request Status" "LOW (0),HIGH (1),%x..."

; ----------------- DMA_CHNL_SW_REQUEST member of dma_sh -----------------

  group 0x0014++0x0003
    line.long 0x000 "DMA_CHNL_SW_REQUEST, Channel Software Request"
    textline "                   "
    bitfld.long 0x0 0.--15. " CHNL_SW_REQUEST           ,CHNL_SW_REQUEST" "DONT_CARE (0),REQ (1),%x..."

; ---------------- DMA_CHNL_USEBURST_SET member of dma_sh ----------------

  group 0x0018++0x0003
    line.long 0x000 "DMA_CHNL_USEBURST_?, Channel Useburst Set"
    textline "                   "
    bitfld.long 0x0 0.--15. " CHNL_USEBURST_SET         ,CHNL_USEBURST_SET" "NO_CHANGE (0),SET (1),%x..."

; ---------------- DMA_CHNL_USEBURST_CLR member of dma_sh ----------------

  group 0x001C++0x0003
    line.long 0x000 "DMA_CHNL_USEBURST_?, Channel Useburst Clear"
    textline "                   "
    bitfld.long 0x0 0.--15. " CHNL_USEBURST_CLR         ,CHNL_USEBURST_CLR" "NO_CLR (0),CLR (1),%x..."

; ---------------- DMA_CHNL_REQ_MASK_SET member of dma_sh ----------------

  group 0x0020++0x0003
    line.long 0x000 "DMA_CHNL_REQ_MASK_?, Channel Request Mask Set "
    textline "                   "
    bitfld.long 0x0 0.--15. " CHNL_REQ_MASK_SET         ,CHNL_REQ_MASK_SET" "NO_CHANGE (0),SET (1),%x..."

; ---------------- DMA_CHNL_REQ_MASK_CLR member of dma_sh ----------------

  group 0x0024++0x0003
    line.long 0x000 "DMA_CHNL_REQ_MASK_?, Channel Request Mask Clear "
    textline "                   "
    bitfld.long 0x0 0.--15. " CHNL_REQ_MASK_CLR         ,CHNL_REQ_MASK_CLR" "NO_CLR (0),CLR (1),%x..."

; ----------------- DMA_CHNL_ENABLE_SET member of dma_sh -----------------

  group 0x0028++0x0003
    line.long 0x000 "DMA_CHNL_ENABLE_SET, Channel Enable Set"
    textline "                   "
    bitfld.long 0x0 0.--15. " CHNL_ENABLE_SET           ,CHNL_ENABLE_SET" "NO_CHANGE (0),SET (1),%x..."

; ----------------- DMA_CHNL_ENABLE_CLR member of dma_sh -----------------

  group 0x002C++0x0003
    line.long 0x000 "DMA_CHNL_ENABLE_CLR, Channel Enable Clear"
    textline "                   "
    bitfld.long 0x0 0.--15. " CHNL_ENABLE_CLR           ,CHNL_ENABLE_CLR" "NO_CLR (0),CLR (1),%x..."

; ---------------- DMA_CHNL_PRI_ALT_SET member of dma_sh ----------------

  group 0x0030++0x0003
    line.long 0x000 "DMA_CHNL_PRI_ALT_S?, Channel Primary-Alternate Set"
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " CHNL_PRI_ALT_SET          ,CHNL_PRI_ALT_SET"

; ---------------- DMA_CHNL_PRI_ALT_CLR member of dma_sh ----------------

  group 0x0034++0x0003
    line.long 0x000 "DMA_CHNL_PRI_ALT_C?, Channel Primary-Alternate Clear"
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " CHNL_PRI_ALT_CLR          ,CHNL_PRI_ALT_CLR"

; ---------------- DMA_CHNL_PRIORITY_SET member of dma_sh ----------------

  group 0x0038++0x0003
    line.long 0x000 "DMA_CHNL_PRIORITY_?, Channel Priority Set"
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " CHNL_PRIORITY_SET         ,CHNL_PRIORITY_SET"

; ---------------- DMA_CHNL_PRIORITY_CLR member of dma_sh ----------------

  group 0x003C++0x0003
    line.long 0x000 "DMA_CHNL_PRIORITY_?, Channel Priority Clear"
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " CHNL_PRIORITY_CLR         ,CHNL_PRIORITY_CLR"

; --------------------- DMA_ERR_CLR member of dma_sh ---------------------

  group 0x004C++0x0003
    line.long 0x000 "DMA_ERR_CLR, Bus Error Clear"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " ERR_CLR                   ,ERR_CLR"

; ------------------------- RIS member of dma_sh -------------------------

  rgroup 0x1000++0x0003
    line.long 0x000 "RIS, Raw Interrupt Status Register"
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " DMA_CH_INT_STATUS         ,DMA Channel_15 Interrupt."
    textline "                   "
    hexmask.long.byte 0x0 31.--31. 0x1 0x0 " DMA_ERR_INT_STATUS        ,DMA Error Interrupt."

; ------------------------ IMSC member of dma_sh ------------------------

  group 0x1004++0x0003
    line.long 0x000 "IMSC, Interrupt Mask Control Register"
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " DMA_CH_MSK                ,Mask bit for DMA Channel_15 Interrupt."
    textline "                   "
    hexmask.long.byte 0x0 31.--31. 0x1 0x0 " DMA_ERR_MSK               ,Mask bit for DMA Error Interrupt."

; ------------------------- MIS member of dma_sh -------------------------

  rgroup 0x1008++0x0003
    line.long 0x000 "MIS, Masked Interrupt Status Register"
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " DMA_CH_INT                ,DMA Channel_15 Interrupt."
    textline "                   "
    hexmask.long.byte 0x0 31.--31. 0x1 0x0 " DMA_ERR_INT               ,DMA Error Interrupt."

; ------------------------- ICR member of dma_sh -------------------------

  group 0x100C++0x0003
    line.long 0x000 "ICR, Interrupt Clear Register"
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " DMA_CH_INT_CLR            ,Clear bit for DMA Channel_15 Interrupt."
    textline "                   "
    hexmask.long.byte 0x0 31.--31. 0x1 0x0 " DMA_ERR_INT_CLR           ,Clear bit for DMA Error Interrupt."

; ------------------------- ISR member of dma_sh -------------------------

  group 0x1010++0x0003
    line.long 0x000 "ISR, Interrupt Set Register"
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " DMA_CH_INT_SET            ,Set bit for DMA Channel_15 Interrupt."
    textline "                   "
    hexmask.long.byte 0x0 31.--31. 0x1 0x0 " DMA_ERR_INT_SET           ,Set bit for DMA Error Interrupt."

tree.end

; -------------------------------------------------------------------
; End Block - dma_sh
; -------------------------------------------------------------------
tree.end
; @file:      dtimer.per
; Chip name:  SHASTA
; Module:     dtimer
; 
; Generated by the pmm metagen library.
;
; ===================================================================
; Copyright (C) 2018 Infineon Technologies AG
; All rights reserved.
; ===================================================================
;
; ===================================================================
; This document contains proprietary information. Passing on and
; copying of this document, and communication of its contents is not
; permitted without prior written authorisation.
; ===================================================================

; This file is automatically generated. Do not edit!


config 32. 8.
width 20.

tree "Block - dtimer"
; -------------------------------------------------------------------
; Begin Block - dtimer
; -------------------------------------------------------------------
base D:0x60010000

tree "timer_0"
; ------------------ TIM_SEQ sequence member of TIM_SEQ ------------------

tree "TIM_SEQ"
tree "TIM_SEQ #0"
; --------------------- TIMERLOAD member of TIM_SEQ ---------------------

  group 0x0000++0x0003
    line.long 0x000 "TIMERLOAD, Load Register"
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " LOAD                      ,Load Counter Value"

; --------------------- TIMERVALUE member of TIM_SEQ ---------------------

  rgroup 0x0004++0x0003
    line.long 0x000 "TIMERVALUE, Value Register"
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " VALUE                     ,Current Counter Value"

; -------------------- TIMERCONTROL member of TIM_SEQ --------------------

  group 0x0008++0x0003
    line.long 0x000 "TIMERCONTROL, Timer Control Register"
    textline "                   "
    bitfld.long 0x0 0. " ONESHOT                   ,One Shot Count" "S0 (0),S1 (1)"
    textline "                   "
    bitfld.long 0x0 1. " TSIZE                     ,Timer Size" "S0 (0),S1 (1)"
    textline "                   "
    bitfld.long 0x0 2.--3. " TPRE                      ,Timer Prescaler" "S0 (0),S1 (1),S2 (2),S3 (3)"
    textline "                   "
    bitfld.long 0x0 5. " INTEN                     ,Interrupt Enable" "S0 (0),S1 (1)"
    textline "                   "
    bitfld.long 0x0 6. " TMODE                     ,Timer Mode" "S0 (0),S1 (1)"
    textline "                   "
    bitfld.long 0x0 7. " TEN                       ,Timer Enable" "S0 (0),S1 (1)"

; -------------------- TIMERINTCLR member of TIM_SEQ --------------------

  group 0x000C++0x0003
    line.long 0x000 "TIMERINTCLR, Interrupt Clear Register"
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " CLRINT                    ,Interrupt Clear"

; ---------------------- TIMERRIS member of TIM_SEQ ----------------------

  rgroup 0x0010++0x0003
    line.long 0x000 "TIMERRIS, Raw Interrupt Status Register"
    textline "                   "
    bitfld.long 0x0 0. " RAWINT                    ,Raw Interrupt Status" "S0 (0),S1 (1)"

; ---------------------- TIMERMIS member of TIM_SEQ ----------------------

  rgroup 0x0014++0x0003
    line.long 0x000 "TIMERMIS, Masked Interrupt Status Register"
    textline "                   "
    bitfld.long 0x0 0. " STINT                     ,Timer Interrupt Status" "S0 (0),S1 (1)"

; -------------------- TIMERBGLOAD member of TIM_SEQ --------------------

  group 0x0018++0x0003
    line.long 0x000 "TIMERBGLOAD, Backgorund Load Register"
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " BVALUE                    ,Backgound Counter Value"

tree.end
tree "TIM_SEQ #1"
; --------------------- TIMERLOAD member of TIM_SEQ ---------------------

  group 0x0020++0x0003
    line.long 0x000 "TIMERLOAD, Load Register"
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " LOAD                      ,Load Counter Value"

; --------------------- TIMERVALUE member of TIM_SEQ ---------------------

  rgroup 0x0024++0x0003
    line.long 0x000 "TIMERVALUE, Value Register"
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " VALUE                     ,Current Counter Value"

; -------------------- TIMERCONTROL member of TIM_SEQ --------------------

  group 0x0028++0x0003
    line.long 0x000 "TIMERCONTROL, Timer Control Register"
    textline "                   "
    bitfld.long 0x0 0. " ONESHOT                   ,One Shot Count" "S0 (0),S1 (1)"
    textline "                   "
    bitfld.long 0x0 1. " TSIZE                     ,Timer Size" "S0 (0),S1 (1)"
    textline "                   "
    bitfld.long 0x0 2.--3. " TPRE                      ,Timer Prescaler" "S0 (0),S1 (1),S2 (2),S3 (3)"
    textline "                   "
    bitfld.long 0x0 5. " INTEN                     ,Interrupt Enable" "S0 (0),S1 (1)"
    textline "                   "
    bitfld.long 0x0 6. " TMODE                     ,Timer Mode" "S0 (0),S1 (1)"
    textline "                   "
    bitfld.long 0x0 7. " TEN                       ,Timer Enable" "S0 (0),S1 (1)"

; -------------------- TIMERINTCLR member of TIM_SEQ --------------------

  group 0x002C++0x0003
    line.long 0x000 "TIMERINTCLR, Interrupt Clear Register"
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " CLRINT                    ,Interrupt Clear"

; ---------------------- TIMERRIS member of TIM_SEQ ----------------------

  rgroup 0x0030++0x0003
    line.long 0x000 "TIMERRIS, Raw Interrupt Status Register"
    textline "                   "
    bitfld.long 0x0 0. " RAWINT                    ,Raw Interrupt Status" "S0 (0),S1 (1)"

; ---------------------- TIMERMIS member of TIM_SEQ ----------------------

  rgroup 0x0034++0x0003
    line.long 0x000 "TIMERMIS, Masked Interrupt Status Register"
    textline "                   "
    bitfld.long 0x0 0. " STINT                     ,Timer Interrupt Status" "S0 (0),S1 (1)"

; -------------------- TIMERBGLOAD member of TIM_SEQ --------------------

  group 0x0038++0x0003
    line.long 0x000 "TIMERBGLOAD, Backgorund Load Register"
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " BVALUE                    ,Backgound Counter Value"

tree.end

tree.end
tree.end
base D:0x60020000

tree "timer_1"
; ------------------ TIM_SEQ sequence member of TIM_SEQ ------------------

tree "TIM_SEQ"
tree "TIM_SEQ #0"
; --------------------- TIMERLOAD member of TIM_SEQ ---------------------

  group 0x0000++0x0003
    line.long 0x000 "TIMERLOAD, Load Register"
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " LOAD                      ,Load Counter Value"

; --------------------- TIMERVALUE member of TIM_SEQ ---------------------

  rgroup 0x0004++0x0003
    line.long 0x000 "TIMERVALUE, Value Register"
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " VALUE                     ,Current Counter Value"

; -------------------- TIMERCONTROL member of TIM_SEQ --------------------

  group 0x0008++0x0003
    line.long 0x000 "TIMERCONTROL, Timer Control Register"
    textline "                   "
    bitfld.long 0x0 0. " ONESHOT                   ,One Shot Count" "S0 (0),S1 (1)"
    textline "                   "
    bitfld.long 0x0 1. " TSIZE                     ,Timer Size" "S0 (0),S1 (1)"
    textline "                   "
    bitfld.long 0x0 2.--3. " TPRE                      ,Timer Prescaler" "S0 (0),S1 (1),S2 (2),S3 (3)"
    textline "                   "
    bitfld.long 0x0 5. " INTEN                     ,Interrupt Enable" "S0 (0),S1 (1)"
    textline "                   "
    bitfld.long 0x0 6. " TMODE                     ,Timer Mode" "S0 (0),S1 (1)"
    textline "                   "
    bitfld.long 0x0 7. " TEN                       ,Timer Enable" "S0 (0),S1 (1)"

; -------------------- TIMERINTCLR member of TIM_SEQ --------------------

  group 0x000C++0x0003
    line.long 0x000 "TIMERINTCLR, Interrupt Clear Register"
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " CLRINT                    ,Interrupt Clear"

; ---------------------- TIMERRIS member of TIM_SEQ ----------------------

  rgroup 0x0010++0x0003
    line.long 0x000 "TIMERRIS, Raw Interrupt Status Register"
    textline "                   "
    bitfld.long 0x0 0. " RAWINT                    ,Raw Interrupt Status" "S0 (0),S1 (1)"

; ---------------------- TIMERMIS member of TIM_SEQ ----------------------

  rgroup 0x0014++0x0003
    line.long 0x000 "TIMERMIS, Masked Interrupt Status Register"
    textline "                   "
    bitfld.long 0x0 0. " STINT                     ,Timer Interrupt Status" "S0 (0),S1 (1)"

; -------------------- TIMERBGLOAD member of TIM_SEQ --------------------

  group 0x0018++0x0003
    line.long 0x000 "TIMERBGLOAD, Backgorund Load Register"
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " BVALUE                    ,Backgound Counter Value"

tree.end
tree "TIM_SEQ #1"
; --------------------- TIMERLOAD member of TIM_SEQ ---------------------

  group 0x0020++0x0003
    line.long 0x000 "TIMERLOAD, Load Register"
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " LOAD                      ,Load Counter Value"

; --------------------- TIMERVALUE member of TIM_SEQ ---------------------

  rgroup 0x0024++0x0003
    line.long 0x000 "TIMERVALUE, Value Register"
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " VALUE                     ,Current Counter Value"

; -------------------- TIMERCONTROL member of TIM_SEQ --------------------

  group 0x0028++0x0003
    line.long 0x000 "TIMERCONTROL, Timer Control Register"
    textline "                   "
    bitfld.long 0x0 0. " ONESHOT                   ,One Shot Count" "S0 (0),S1 (1)"
    textline "                   "
    bitfld.long 0x0 1. " TSIZE                     ,Timer Size" "S0 (0),S1 (1)"
    textline "                   "
    bitfld.long 0x0 2.--3. " TPRE                      ,Timer Prescaler" "S0 (0),S1 (1),S2 (2),S3 (3)"
    textline "                   "
    bitfld.long 0x0 5. " INTEN                     ,Interrupt Enable" "S0 (0),S1 (1)"
    textline "                   "
    bitfld.long 0x0 6. " TMODE                     ,Timer Mode" "S0 (0),S1 (1)"
    textline "                   "
    bitfld.long 0x0 7. " TEN                       ,Timer Enable" "S0 (0),S1 (1)"

; -------------------- TIMERINTCLR member of TIM_SEQ --------------------

  group 0x002C++0x0003
    line.long 0x000 "TIMERINTCLR, Interrupt Clear Register"
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " CLRINT                    ,Interrupt Clear"

; ---------------------- TIMERRIS member of TIM_SEQ ----------------------

  rgroup 0x0030++0x0003
    line.long 0x000 "TIMERRIS, Raw Interrupt Status Register"
    textline "                   "
    bitfld.long 0x0 0. " RAWINT                    ,Raw Interrupt Status" "S0 (0),S1 (1)"

; ---------------------- TIMERMIS member of TIM_SEQ ----------------------

  rgroup 0x0034++0x0003
    line.long 0x000 "TIMERMIS, Masked Interrupt Status Register"
    textline "                   "
    bitfld.long 0x0 0. " STINT                     ,Timer Interrupt Status" "S0 (0),S1 (1)"

; -------------------- TIMERBGLOAD member of TIM_SEQ --------------------

  group 0x0038++0x0003
    line.long 0x000 "TIMERBGLOAD, Backgorund Load Register"
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " BVALUE                    ,Backgound Counter Value"

tree.end

tree.end
tree.end
base D:0x60030000

tree "timer_2"
; ------------------ TIM_SEQ sequence member of TIM_SEQ ------------------

tree "TIM_SEQ"
tree "TIM_SEQ #0"
; --------------------- TIMERLOAD member of TIM_SEQ ---------------------

  group 0x0000++0x0003
    line.long 0x000 "TIMERLOAD, Load Register"
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " LOAD                      ,Load Counter Value"

; --------------------- TIMERVALUE member of TIM_SEQ ---------------------

  rgroup 0x0004++0x0003
    line.long 0x000 "TIMERVALUE, Value Register"
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " VALUE                     ,Current Counter Value"

; -------------------- TIMERCONTROL member of TIM_SEQ --------------------

  group 0x0008++0x0003
    line.long 0x000 "TIMERCONTROL, Timer Control Register"
    textline "                   "
    bitfld.long 0x0 0. " ONESHOT                   ,One Shot Count" "S0 (0),S1 (1)"
    textline "                   "
    bitfld.long 0x0 1. " TSIZE                     ,Timer Size" "S0 (0),S1 (1)"
    textline "                   "
    bitfld.long 0x0 2.--3. " TPRE                      ,Timer Prescaler" "S0 (0),S1 (1),S2 (2),S3 (3)"
    textline "                   "
    bitfld.long 0x0 5. " INTEN                     ,Interrupt Enable" "S0 (0),S1 (1)"
    textline "                   "
    bitfld.long 0x0 6. " TMODE                     ,Timer Mode" "S0 (0),S1 (1)"
    textline "                   "
    bitfld.long 0x0 7. " TEN                       ,Timer Enable" "S0 (0),S1 (1)"

; -------------------- TIMERINTCLR member of TIM_SEQ --------------------

  group 0x000C++0x0003
    line.long 0x000 "TIMERINTCLR, Interrupt Clear Register"
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " CLRINT                    ,Interrupt Clear"

; ---------------------- TIMERRIS member of TIM_SEQ ----------------------

  rgroup 0x0010++0x0003
    line.long 0x000 "TIMERRIS, Raw Interrupt Status Register"
    textline "                   "
    bitfld.long 0x0 0. " RAWINT                    ,Raw Interrupt Status" "S0 (0),S1 (1)"

; ---------------------- TIMERMIS member of TIM_SEQ ----------------------

  rgroup 0x0014++0x0003
    line.long 0x000 "TIMERMIS, Masked Interrupt Status Register"
    textline "                   "
    bitfld.long 0x0 0. " STINT                     ,Timer Interrupt Status" "S0 (0),S1 (1)"

; -------------------- TIMERBGLOAD member of TIM_SEQ --------------------

  group 0x0018++0x0003
    line.long 0x000 "TIMERBGLOAD, Backgorund Load Register"
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " BVALUE                    ,Backgound Counter Value"

tree.end
tree "TIM_SEQ #1"
; --------------------- TIMERLOAD member of TIM_SEQ ---------------------

  group 0x0020++0x0003
    line.long 0x000 "TIMERLOAD, Load Register"
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " LOAD                      ,Load Counter Value"

; --------------------- TIMERVALUE member of TIM_SEQ ---------------------

  rgroup 0x0024++0x0003
    line.long 0x000 "TIMERVALUE, Value Register"
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " VALUE                     ,Current Counter Value"

; -------------------- TIMERCONTROL member of TIM_SEQ --------------------

  group 0x0028++0x0003
    line.long 0x000 "TIMERCONTROL, Timer Control Register"
    textline "                   "
    bitfld.long 0x0 0. " ONESHOT                   ,One Shot Count" "S0 (0),S1 (1)"
    textline "                   "
    bitfld.long 0x0 1. " TSIZE                     ,Timer Size" "S0 (0),S1 (1)"
    textline "                   "
    bitfld.long 0x0 2.--3. " TPRE                      ,Timer Prescaler" "S0 (0),S1 (1),S2 (2),S3 (3)"
    textline "                   "
    bitfld.long 0x0 5. " INTEN                     ,Interrupt Enable" "S0 (0),S1 (1)"
    textline "                   "
    bitfld.long 0x0 6. " TMODE                     ,Timer Mode" "S0 (0),S1 (1)"
    textline "                   "
    bitfld.long 0x0 7. " TEN                       ,Timer Enable" "S0 (0),S1 (1)"

; -------------------- TIMERINTCLR member of TIM_SEQ --------------------

  group 0x002C++0x0003
    line.long 0x000 "TIMERINTCLR, Interrupt Clear Register"
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " CLRINT                    ,Interrupt Clear"

; ---------------------- TIMERRIS member of TIM_SEQ ----------------------

  rgroup 0x0030++0x0003
    line.long 0x000 "TIMERRIS, Raw Interrupt Status Register"
    textline "                   "
    bitfld.long 0x0 0. " RAWINT                    ,Raw Interrupt Status" "S0 (0),S1 (1)"

; ---------------------- TIMERMIS member of TIM_SEQ ----------------------

  rgroup 0x0034++0x0003
    line.long 0x000 "TIMERMIS, Masked Interrupt Status Register"
    textline "                   "
    bitfld.long 0x0 0. " STINT                     ,Timer Interrupt Status" "S0 (0),S1 (1)"

; -------------------- TIMERBGLOAD member of TIM_SEQ --------------------

  group 0x0038++0x0003
    line.long 0x000 "TIMERBGLOAD, Backgorund Load Register"
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " BVALUE                    ,Backgound Counter Value"

tree.end

tree.end
tree.end

; -------------------------------------------------------------------
; End Block - dtimer
; -------------------------------------------------------------------
tree.end
; @file:      fan.per
; Chip name:  SHASTA
; Module:     fan
; 
; Generated by the pmm metagen library.
;
; ===================================================================
; Copyright (C) 2018 Infineon Technologies AG
; All rights reserved.
; ===================================================================
;
; ===================================================================
; This document contains proprietary information. Passing on and
; copying of this document, and communication of its contents is not
; permitted without prior written authorisation.
; ===================================================================

; This file is automatically generated. Do not edit!


config 32. 8.
width 20.

tree "Block - fan"
; -------------------------------------------------------------------
; Begin Block - fan
; -------------------------------------------------------------------
base D:0x70004400

tree "fan1"
; ----------------------- FAN_CONFIG member of fan -----------------------

  group 0x0000++0x0003
    line.long 0x000 "FAN_CONFIG, Fan maximum current reference when operating in current mode.  When the output current exceeds fan_imax the output duty cycle will be 100%.  See fan_imin for the current mode current to duty cycle equation."
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " fan_imax                  ,Fan maximum current reference when operating in current mode.  When the output current exceeds fan_imax the output duty cycle will be 100%.  See fan_imin for the current mode current to duty cycle equation."
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " fan_imin                  ,Fan minimum current reference when operating in current mode.  When the output current is less than fan_imin the output duty cycle will be zero.  When the output current exceeds fan_imin the output duty cycle is given by the equation, "
    textline "                   "
    hexmask.long.byte 0x0 16.--23. 0x1 0x0 " fan_duty_min              ,Fan minimum duty cycle when operating in current mode.    See fan_imin for the current mode current to duty cycle equation."
    textline "                   "
    hexmask.long.byte 0x0 24.--25. 0x1 0x0 " fan_freq                  ,Fan switching frequency "
    textline "                   "
    hexmask.long.byte 0x0 26.--27. 0x1 0x0 " fan_tach_ppr              ,Tachometer pulses per revolution (ppr) "
    textline "                   "
    hexmask.long.byte 0x0 28.--28. 0x1 0x0 " fan_mode                  ,Fan operating mode "
    textline "                   "
    hexmask.long.byte 0x0 29.--29. 0x1 0x0 " fan_iout_sel              ,Fan IOUT source when operating in current mode "

; ------------------------ FAN_DUTY member of fan ------------------------

  group 0x0004++0x0003
    line.long 0x000 "FAN_DUTY, Fan commanded duty cycle when operating in duty cycle mode.  Note fan_duty=0xFF overrides to 100%. Computed from PMBus command as follows: "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " fan_duty                  ,Fan commanded duty cycle when operating in duty cycle mode.  Note fan_duty=0xFF overrides to 100%. Computed from PMBus command as follows: "

; ----------------------- FAN_SPEED member of fan -----------------------

  rgroup 0x0008++0x0003
    line.long 0x000 "FAN_SPEED, Fan speed in rotations per minute (RPM) as measured at the fan_tach_i input. PMBus command computed as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--11. 0x1 0x0 " fan_speed                 ,Fan speed in rotations per minute (RPM) as measured at the fan_tach_i input. PMBus command computed as follows: "

tree.end
base D:0x70004800

tree "fan2"
; ----------------------- FAN_CONFIG member of fan -----------------------

  group 0x0000++0x0003
    line.long 0x000 "FAN_CONFIG, Fan maximum current reference when operating in current mode.  When the output current exceeds fan_imax the output duty cycle will be 100%.  See fan_imin for the current mode current to duty cycle equation."
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " fan_imax                  ,Fan maximum current reference when operating in current mode.  When the output current exceeds fan_imax the output duty cycle will be 100%.  See fan_imin for the current mode current to duty cycle equation."
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " fan_imin                  ,Fan minimum current reference when operating in current mode.  When the output current is less than fan_imin the output duty cycle will be zero.  When the output current exceeds fan_imin the output duty cycle is given by the equation, "
    textline "                   "
    hexmask.long.byte 0x0 16.--23. 0x1 0x0 " fan_duty_min              ,Fan minimum duty cycle when operating in current mode.    See fan_imin for the current mode current to duty cycle equation."
    textline "                   "
    hexmask.long.byte 0x0 24.--25. 0x1 0x0 " fan_freq                  ,Fan switching frequency "
    textline "                   "
    hexmask.long.byte 0x0 26.--27. 0x1 0x0 " fan_tach_ppr              ,Tachometer pulses per revolution (ppr) "
    textline "                   "
    hexmask.long.byte 0x0 28.--28. 0x1 0x0 " fan_mode                  ,Fan operating mode "
    textline "                   "
    hexmask.long.byte 0x0 29.--29. 0x1 0x0 " fan_iout_sel              ,Fan IOUT source when operating in current mode "

; ------------------------ FAN_DUTY member of fan ------------------------

  group 0x0004++0x0003
    line.long 0x000 "FAN_DUTY, Fan commanded duty cycle when operating in duty cycle mode.  Note fan_duty=0xFF overrides to 100%. Computed from PMBus command as follows: "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " fan_duty                  ,Fan commanded duty cycle when operating in duty cycle mode.  Note fan_duty=0xFF overrides to 100%. Computed from PMBus command as follows: "

; ----------------------- FAN_SPEED member of fan -----------------------

  rgroup 0x0008++0x0003
    line.long 0x000 "FAN_SPEED, Fan speed in rotations per minute (RPM) as measured at the fan_tach_i input. PMBus command computed as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--11. 0x1 0x0 " fan_speed                 ,Fan speed in rotations per minute (RPM) as measured at the fan_tach_i input. PMBus command computed as follows: "

tree.end

; -------------------------------------------------------------------
; End Block - fan
; -------------------------------------------------------------------
tree.end
; @file:      fault.per
; Chip name:  SHASTA
; Module:     fault
; 
; Generated by the pmm metagen library.
;
; ===================================================================
; Copyright (C) 2018 Infineon Technologies AG
; All rights reserved.
; ===================================================================
;
; ===================================================================
; This document contains proprietary information. Passing on and
; copying of this document, and communication of its contents is not
; permitted without prior written authorisation.
; ===================================================================

; This file is automatically generated. Do not edit!


config 32. 8.
width 20.

tree "Block - fault"
; -------------------------------------------------------------------
; Begin Block - fault
; -------------------------------------------------------------------
base D:0x70003C00

tree "fault0"
; ---------------------- FAULT_CNT member of fault ----------------------

  group 0x0000++0x0003
    line.long 0x000 "FAULT_CNT, Output over voltage fault count.  Defines the number of consecutive 50MHz samples the output voltage must exceed the fault threshold in order to assert a fault. "
    textline "                   "
    hexmask.long.byte 0x0 0.--1. 0x1 0x0 " fault_vout_ov_fault_cnt   ,Output over voltage fault count.  Defines the number of consecutive 50MHz samples the output voltage must exceed the fault threshold in order to assert a fault. "
    textline "                   "
    hexmask.long.byte 0x0 2.--3. 0x1 0x0 " fault_vout_ov_warn_cnt    ,Output over voltage warning count.  Defines the number of consecutive 50MHz samples the output voltage must exceed the warn threshold in order to assert a warning. "
    textline "                   "
    hexmask.long.byte 0x0 4.--5. 0x1 0x0 " fault_vout_uv_fault_cnt   ,Output under voltage fault count.  Defines the number of consecutive 50MHz samples the output voltage must exceed the fault threshold in order to assert a fault. "
    textline "                   "
    hexmask.long.byte 0x0 6.--7. 0x1 0x0 " fault_vout_uv_warn_cnt    ,Output under voltage warning count.  Defines the number of consecutive 50MHz samples the output voltage must exceed the warn threshold in order to assert a warning. "
    textline "                   "
    hexmask.long.byte 0x0 8.--12. 0x1 0x0 " fault_iout_oc_fault_cnt   ,Output over current fault count.  Defines the number of consecutive switching cycles (Tsw) the low pass filtered current must exceed the fault threshold in order to assert a fault."
    textline "                   "
    hexmask.long.byte 0x0 13.--17. 0x1 0x0 " fault_iout_oc_warn_cnt    ,Output over current warning count.  Defines the number of consecutive switching cycles (Tsw) the low pass filtered current must exceed the warn threshold in order to assert a warning."
    textline "                   "
    hexmask.long.byte 0x0 18.--22. 0x1 0x0 " fault_mfr_iout_oc_fast_c? ,MFR_IOUT_OC_FAST over current fault count.  Defines the number of consecutive switching cycles (Tsw) the cycle averaged current must exceed the fault threshold in order to assert a fault."
    textline "                   "
    hexmask.long.byte 0x0 23.--27. 0x1 0x0 " fault_iout_uc_fault_cnt   ,Output under current fault count.  Defines the number of consecutive switching cycles (Tsw) the cycle averaged current must exceed the fault threshold in order to assert a fault."

; ------------------ FAULT_CNT_VIN_IIN member of fault ------------------

  group 0x0004++0x0003
    line.long 0x000 "FAULT_CNT_VIN_IIN, Input over voltage fault count.  Defines the number of consecutive switching cycles (Tsw) the input voltage must exceed the fault threshold in order to assert a fault. "
    textline "                   "
    hexmask.long.byte 0x0 0.--1. 0x1 0x0 " fault_vin_ov_fault_cnt    ,Input over voltage fault count.  Defines the number of consecutive switching cycles (Tsw) the input voltage must exceed the fault threshold in order to assert a fault. "
    textline "                   "
    hexmask.long.byte 0x0 2.--3. 0x1 0x0 " fault_vin_ov_warn_cnt     ,Input over voltage warning count.  Defines the number of consecutive switching cycles (Tsw) the input voltage must exceed the warn threshold in order to assert a warning "
    textline "                   "
    hexmask.long.byte 0x0 4.--5. 0x1 0x0 " fault_vin_uv_fault_cnt    ,Input under voltage fault count.  Defines the number of consecutive switching cycles (Tsw) the input voltage must exceed the fault threshold in order to assert a fault. "
    textline "                   "
    hexmask.long.byte 0x0 6.--7. 0x1 0x0 " fault_vin_uv_warn_cnt     ,Input under voltage warning count.  Defines the number of consecutive switching cycles (Tsw) the input voltage must exceed the warn threshold in order to assert a warning "
    textline "                   "
    hexmask.long.byte 0x0 8.--12. 0x1 0x0 " fault_iin_oc_fault_cnt    ,Input over current fault count.  Defines the number of consecutive switching cycles (Tsw) the low pass filtered input current must exceed the fault threshold in order to assert a fault."
    textline "                   "
    hexmask.long.byte 0x0 13.--17. 0x1 0x0 " fault_iin_oc_warn_cnt     ,Input over current warning count.  Defines the number of consecutive switching cycles (Tsw) the low pass filtered input current must exceed the warn threshold in order to assert a warning"
    textline "                   "
    hexmask.long.byte 0x0 18.--23. 0x1 0x0 " fault_vin_fault_hyst      ,Input voltage (VIN) fault / warn deassertion hysteresis."

; ---------------------- FAULT_HYST member of fault ----------------------

  group 0x0008++0x0003
    line.long 0x000 "FAULT_HYST, Output voltage (VOUT) fault / warn deassertion hysteresis."
    textline "                   "
    hexmask.long.byte 0x0 0.--4. 0x1 0x0 " fault_vout_fault_hyst     ,Output voltage (VOUT) fault / warn deassertion hysteresis."
    textline "                   "
    hexmask.long.byte 0x0 5.--9. 0x1 0x0 " fault_iin_fault_hyst      ,Input current (IIN) fault / warn deassertion hysteresis."
    textline "                   "
    hexmask.long.byte 0x0 10.--15. 0x1 0x0 " fault_iout_oc_fault_hyst  ,Output over current (IOUT_OC) fault / warn deassertion hysteresis."
    textline "                   "
    hexmask.long.byte 0x0 16.--21. 0x1 0x0 " fault_iout_uc_fault_hyst  ,Output under current (IOUT_UC) fault / warn deassertion hysteresis."
    textline "                   "
    hexmask.long.byte 0x0 22.--26. 0x1 0x0 " fault_temp_fault_hyst     ,Temperature fault / warn deassertion hysteresis."

; ----------------- FAULT_SHUT_MASK_LOOP member of fault -----------------

  group 0x000C++0x0003
    line.long 0x000 "FAULT_SHUT_MASK_LO?, Shutdown mask for  Loop  faults.  Individual faults are enabled for shutdown when their corresponding bit is high.  Enabled faults disable the loop output and assert the shutdown interrupt immediately upon fault assertion. "
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " fault_shut_mask_loop      ,Shutdown mask for  Loop  faults.  Individual faults are enabled for shutdown when their corresponding bit is high.  Enabled faults disable the loop output and assert the shutdown interrupt immediately upon fault assertion. "

; ------------------ FAULT_T2_SHUT_MASK member of fault ------------------

  group 0x0010++0x0003
    line.long 0x000 "FAULT_T2_SHUT_MASK,  T2  shutdown mask for  Loop  faults.  Individual faults are enabled for T2 shutdown when their corresponding bit is high.  Enabled faults disable the loop output and assert the shutdown interrupt aligned with the T2 ramp time which typically aligns with the falling edge of the primary side PWM pulse.  Note that when corresponding bits in both fault_shut_mask_loop and fault_t2_shut_mask_loop are set to 1, the immediate shutdown behavior of fault_shut_mask_loop is implemented. "
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " fault_t2_shut_mask_loop   , T2  shutdown mask for  Loop  faults.  Individual faults are enabled for T2 shutdown when their corresponding bit is high.  Enabled faults disable the loop output and assert the shutdown interrupt aligned with the T2 ramp time which typically aligns with the falling edge of the primary side PWM pulse.  Note that when corresponding bits in both fault_shut_mask_loop and fault_t2_shut_mask_loop are set to 1, the immediate shutdown behavior of fault_shut_mask_loop is implemented. "

; ------------------ FAULT_ENABLE_LOOP member of fault ------------------

  group 0x0014++0x0003
    line.long 0x000 "FAULT_ENABLE_LOOP, Fault enable for  Loop  faults.  Individual faults are enabled for fault interrupt generation when their corresponding bit is high. "
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " fault_enable_loop         ,Fault enable for  Loop  faults.  Individual faults are enabled for fault interrupt generation when their corresponding bit is high. "

; ------------------ FAULT_VOUT_OV_FLT member of fault ------------------

  group 0x0018++0x0003
    line.long 0x000 "FAULT_VOUT_OV_FLT, Output over voltage fault threshold.  Note that this threshold is defined with respect to the voltage at the VSEN pin, after the vout sense resistor divider. Computed from PMBus command as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--9. 0x1 0x0 " fault_vout_ov_fault_thre? ,Output over voltage fault threshold.  Note that this threshold is defined with respect to the voltage at the VSEN pin, after the vout sense resistor divider. Computed from PMBus command as follows: "

; ------------------ FAULT_VOUT_OV_WRN member of fault ------------------

  group 0x001C++0x0003
    line.long 0x000 "FAULT_VOUT_OV_WRN, Output over voltage warning threshold.  Note that this threshold is defined with respect to the voltage at the VSEN pin, after the vout sense resistor divider. Computed from PMBus command as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--9. 0x1 0x0 " fault_vout_ov_warn_thresh ,Output over voltage warning threshold.  Note that this threshold is defined with respect to the voltage at the VSEN pin, after the vout sense resistor divider. Computed from PMBus command as follows: "

; ------------------ FAULT_VOUT_UV_FLT member of fault ------------------

  group 0x0020++0x0003
    line.long 0x000 "FAULT_VOUT_UV_FLT, Output under voltage fault threshold.  Note that this threshold is defined with respect to the voltage at the VSEN pin, after the vout sense resistor divider. Computed from PMBus command as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--9. 0x1 0x0 " fault_vout_uv_fault_thre? ,Output under voltage fault threshold.  Note that this threshold is defined with respect to the voltage at the VSEN pin, after the vout sense resistor divider. Computed from PMBus command as follows: "

; ------------------ FAULT_VOUT_UV_WRN member of fault ------------------

  group 0x0024++0x0003
    line.long 0x000 "FAULT_VOUT_UV_WRN, Output under voltage warning threshold.  Note that this threshold is defined with respect to the voltage at the VSEN pin, after the vout sense resistor divider. Computed from PMBus command as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--9. 0x1 0x0 " fault_vout_uv_warn_thresh ,Output under voltage warning threshold.  Note that this threshold is defined with respect to the voltage at the VSEN pin, after the vout sense resistor divider. Computed from PMBus command as follows: "

; ------------------- FAULT_VIN_OV_FLT member of fault -------------------

  group 0x0028++0x0003
    line.long 0x000 "FAULT_VIN_OV_FLT, Input over voltage fault threshold. Computed from PMBus command as follows:   fault_vin_ovp_fault_thresh(U7.3) = (VIN_OV_FAULT_LIMIT(U7.3)*2^-3 "
    textline "                   "
    hexmask.long.word 0x0 0.--9. 0x1 0x0 " fault_vin_ov_fault_thresh ,Input over voltage fault threshold. Computed from PMBus command as follows:   fault_vin_ovp_fault_thresh(U7.3) = (VIN_OV_FAULT_LIMIT(U7.3)*2^-3 "

; ------------------- FAULT_VIN_OV_WRN member of fault -------------------

  group 0x002C++0x0003
    line.long 0x000 "FAULT_VIN_OV_WRN, Input over voltage warning threshold. Computed from PMBus command as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--9. 0x1 0x0 " fault_vin_ov_warn_thresh  ,Input over voltage warning threshold. Computed from PMBus command as follows: "

; ------------------- FAULT_VIN_UV_FLT member of fault -------------------

  group 0x0030++0x0003
    line.long 0x000 "FAULT_VIN_UV_FLT, Input under voltage fault threshold. Computed from PMBus command as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--9. 0x1 0x0 " fault_vin_uv_fault_thresh ,Input under voltage fault threshold. Computed from PMBus command as follows: "

; ------------------- FAULT_VIN_UV_WRN member of fault -------------------

  group 0x0034++0x0003
    line.long 0x000 "FAULT_VIN_UV_WRN, Input under voltage warning threshold. Computed from PMBus command as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--9. 0x1 0x0 " fault_vin_uv_warn_thresh  ,Input under voltage warning threshold. Computed from PMBus command as follows: "

; ------------------ FAULT_IOUT_OC_FLT member of fault ------------------

  group 0x0038++0x0003
    line.long 0x000 "FAULT_IOUT_OC_FLT, Output over current fault threshold Computed from PMBus command as follows: "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " fault_iout_oc_fault_thre? ,Output over current fault threshold Computed from PMBus command as follows: "

; ------------------ FAULT_IOUT_LV_FLT member of fault ------------------

  group 0x003C++0x0003
    line.long 0x000 "FAULT_IOUT_LV_FLT, Output over current low voltage fault threshold.  Note that this threshold is defined with respect to the voltage at the VSEN pin, after the vout sense resistor divider. Computed from PMBus command as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--9. 0x1 0x0 " fault_iout_oc_lv_fault_t? ,Output over current low voltage fault threshold.  Note that this threshold is defined with respect to the voltage at the VSEN pin, after the vout sense resistor divider. Computed from PMBus command as follows: "

; ------------------ FAULT_IOUT_OC_WRN member of fault ------------------

  group 0x0040++0x0003
    line.long 0x000 "FAULT_IOUT_OC_WRN, Output over current warn threshold. Computed from PMBus command as follows: "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " fault_iout_oc_warn_thresh ,Output over current warn threshold. Computed from PMBus command as follows: "

; ------------------ FAULT_IOUT_UC_FLT member of fault ------------------

  group 0x0044++0x0003
    line.long 0x000 "FAULT_IOUT_UC_FLT, Output under current fault threshold.  Fault asserted when the cycle averaged output current is below this threshold. Computed from PMBus command as follows: "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " fault_iout_uc_fault_thre? ,Output under current fault threshold.  Fault asserted when the cycle averaged output current is below this threshold. Computed from PMBus command as follows: "

; ------------------- FAULT_MFR_OC_FLT member of fault -------------------

  group 0x0048++0x0003
    line.long 0x000 "FAULT_MFR_OC_FLT, Fast output over current fault threshold. Computed from PMBus command as follows: "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " fault_mfr_iout_oc_fast_t? ,Fast output over current fault threshold. Computed from PMBus command as follows: "

; ------------------- FAULT_IIN_OC_FLT member of fault -------------------

  group 0x004C++0x0003
    line.long 0x000 "FAULT_IIN_OC_FLT, Input over current fault threshold. Computed from PMBus command as follows: "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " fault_iin_oc_fault_thresh ,Input over current fault threshold. Computed from PMBus command as follows: "

; ------------------- FAULT_IIN_OC_WRN member of fault -------------------

  group 0x0050++0x0003
    line.long 0x000 "FAULT_IIN_OC_WRN, Input over current warning threshold. Computed from PMBus command as follows: "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " fault_iin_oc_warn_thresh  ,Input over current warning threshold. Computed from PMBus command as follows: "

; --------------------- FAULT_OT_FLT member of fault ---------------------

  group 0x0054++0x0003
    line.long 0x000 "FAULT_OT_FLT, Over temperature fault threshold in Telemetry Sense ADC codes.  Note that the ADC Code to Temperature lookup table is implemented in FW."
    textline "                   "
    hexmask.long.word 0x0 0.--9. 0x1 0x0 " fault_ot_fault_thresh     ,Over temperature fault threshold in Telemetry Sense ADC codes.  Note that the ADC Code to Temperature lookup table is implemented in FW."

; --------------------- FAULT_OT_WRN member of fault ---------------------

  group 0x0058++0x0003
    line.long 0x000 "FAULT_OT_WRN, Over temperature warn threshold in Telemetry Sense ADC codes.  Note that the ADC Code to Temperature lookup table is implemented in FW."
    textline "                   "
    hexmask.long.word 0x0 0.--9. 0x1 0x0 " fault_ot_warn_thresh      ,Over temperature warn threshold in Telemetry Sense ADC codes.  Note that the ADC Code to Temperature lookup table is implemented in FW."

; --------------------- FAULT_UT_FLT member of fault ---------------------

  group 0x005C++0x0003
    line.long 0x000 "FAULT_UT_FLT, Under temperature fault threshold in Telemetry Sense ADC codes.  Note that the ADC Code to Temperature lookup table is implemented in FW."
    textline "                   "
    hexmask.long.word 0x0 0.--9. 0x1 0x0 " fault_ut_fault_thresh     ,Under temperature fault threshold in Telemetry Sense ADC codes.  Note that the ADC Code to Temperature lookup table is implemented in FW."

; --------------------- FAULT_UT_WRN member of fault ---------------------

  group 0x0060++0x0003
    line.long 0x000 "FAULT_UT_WRN, Under temperature warn threshold in Telemetry Sense ADC codes.  Note that the ADC Code to Temperature lookup table is implemented in FW."
    textline "                   "
    hexmask.long.word 0x0 0.--9. 0x1 0x0 " fault_ut_warn_thresh      ,Under temperature warn threshold in Telemetry Sense ADC codes.  Note that the ADC Code to Temperature lookup table is implemented in FW."

; --------------------- FAULT_OT_SRC member of fault ---------------------

  group 0x0064++0x0003
    line.long 0x000 "FAULT_OT_SRC, Loop temperature source select. "
    textline "                   "
    hexmask.long.byte 0x0 0.--2. 0x1 0x0 " fault_temp_src_sel        ,Loop temperature source select. "

; ----------------- FAULT_SHUT_CLR_LOOP member of fault -----------------

  group 0x0068++0x0003
    line.long 0x000 "FAULT_SHUT_CLR_LOOP, Clears shutdown faults in fault_reg_loop when set high. This field should not be written until after FW has completed shutdown related cleanup (e.g., Vcontrol target returned to 0, appropriate blocks disabled)."
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " fault_shut_clr_loop       ,Clears shutdown faults in fault_reg_loop when set high. This field should not be written until after FW has completed shutdown related cleanup (e.g., Vcontrol target returned to 0, appropriate blocks disabled)."

; ----------------- FAULT_POLARITY_LOOP member of fault -----------------

  group 0x006C++0x0003
    line.long 0x000 "FAULT_POLARITY_LOOP, Defines the polarity of the fault with respect to the threshold.  When set to 0, the fault / warning is asserted using its default polarity (e.g.,  over  type fault asserted when above the threshold).  When set to 1, the fault / warning is asserted with the inverse to its default polarity (e.g.,  over  type fault asserted when below the threshold).  The inverse polarity may be used to generate an interrupt when a parameter no longer exceeds its fault / warning threshold. "
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " fault_polarity_loop       ,Defines the polarity of the fault with respect to the threshold.  When set to 0, the fault / warning is asserted using its default polarity (e.g.,  over  type fault asserted when above the threshold).  When set to 1, the fault / warning is asserted with the inverse to its default polarity (e.g.,  over  type fault asserted when below the threshold).  The inverse polarity may be used to generate an interrupt when a parameter no longer exceeds its fault / warning threshold. "

; ------------------- FAULT_FORCE_LOOP member of fault -------------------

  group 0x0070++0x0003
    line.long 0x000 "FAULT_FORCE_LOOP, Fault force set register.  When the bit corresponding to a fault / warning is set to 1, that fault / warning is asserted as if it had exceeded its threshold. "
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " fault_force_loop          ,Fault force set register.  When the bit corresponding to a fault / warning is set to 1, that fault / warning is asserted as if it had exceeded its threshold. "

; ------------------- FAULT_CLEAR_LOOP member of fault -------------------

  group 0x0074++0x0003
    line.long 0x000 "FAULT_CLEAR_LOOP, Fault force clear register.  When the bit corresponding to a fault / warning is set to 1, that fault / warning is cleared in the fault_status_loop and fault_ref_loop registers. "
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " fault_clear_loop          ,Fault force clear register.  When the bit corresponding to a fault / warning is set to 1, that fault / warning is cleared in the fault_status_loop and fault_ref_loop registers. "

; ------------------ FAULT_STATUS_LOOP member of fault ------------------

  rgroup 0x0078++0x0003
    line.long 0x000 "FAULT_STATUS_LOOP, Fault status register generated by sub-sampling fault_reg_loop at 2MHz.  Fault interrupts are generated from this register.  Once a fault bit is set it is latched in this register and can only be cleared via fault_clear_loop. "
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " fault_status_loop         ,Fault status register generated by sub-sampling fault_reg_loop at 2MHz.  Fault interrupts are generated from this register.  Once a fault bit is set it is latched in this register and can only be cleared via fault_clear_loop. "

; -------------------- FAULT_REG_LOOP member of fault --------------------

  rgroup 0x007C++0x0003
    line.long 0x000 "FAULT_REG_LOOP, Fault status register updated at 50MHz.  Once a fault bit is set it is latched in this register and can only be cleared via fault_clear_loop. "
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " fault_reg_loop            ,Fault status register updated at 50MHz.  Once a fault bit is set it is latched in this register and can only be cleared via fault_clear_loop. "

; ------------------- FAULT_IOUT_CC_RD member of fault -------------------

  rgroup 0x0080++0x0003
    line.long 0x000 "FAULT_IOUT_CC_RD, Status flag indicating constant current mode. "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " fault_iout_cc_mode        ,Status flag indicating constant current mode. "
    textline "                   "
    hexmask.long.word 0x0 1.--14. 0x1 0x0 " fault_iout_cc_adj         ,Status register indicating magnitude of constant current mode output voltage adjustment referenced to the VSEN pin (i.e., after the Vout sense resistor divider)."

; ------------------ FAULT_IOUT_CC_SEL member of fault ------------------

  group 0x0084++0x0003
    line.long 0x000 "FAULT_IOUT_CC_SEL, Constant current mode enable for IOUT_OC_FAULT.  Set by IOUT_OC_FAULT_RESPONSE. "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " fault_iout_cc_en          ,Constant current mode enable for IOUT_OC_FAULT.  Set by IOUT_OC_FAULT_RESPONSE. "
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " fault_iout_cc_en_fast     ,Constant current mode enable for MFR_IOUT_OC_FAST_FAULT.  Set by MFR_IOUT_OC_FAST_FAULT_RESPONSE. "

tree.end
base D:0x70004000

tree "fault1"
; ---------------------- FAULT_CNT member of fault ----------------------

  group 0x0000++0x0003
    line.long 0x000 "FAULT_CNT, Output over voltage fault count.  Defines the number of consecutive 50MHz samples the output voltage must exceed the fault threshold in order to assert a fault. "
    textline "                   "
    hexmask.long.byte 0x0 0.--1. 0x1 0x0 " fault_vout_ov_fault_cnt   ,Output over voltage fault count.  Defines the number of consecutive 50MHz samples the output voltage must exceed the fault threshold in order to assert a fault. "
    textline "                   "
    hexmask.long.byte 0x0 2.--3. 0x1 0x0 " fault_vout_ov_warn_cnt    ,Output over voltage warning count.  Defines the number of consecutive 50MHz samples the output voltage must exceed the warn threshold in order to assert a warning. "
    textline "                   "
    hexmask.long.byte 0x0 4.--5. 0x1 0x0 " fault_vout_uv_fault_cnt   ,Output under voltage fault count.  Defines the number of consecutive 50MHz samples the output voltage must exceed the fault threshold in order to assert a fault. "
    textline "                   "
    hexmask.long.byte 0x0 6.--7. 0x1 0x0 " fault_vout_uv_warn_cnt    ,Output under voltage warning count.  Defines the number of consecutive 50MHz samples the output voltage must exceed the warn threshold in order to assert a warning. "
    textline "                   "
    hexmask.long.byte 0x0 8.--12. 0x1 0x0 " fault_iout_oc_fault_cnt   ,Output over current fault count.  Defines the number of consecutive switching cycles (Tsw) the low pass filtered current must exceed the fault threshold in order to assert a fault."
    textline "                   "
    hexmask.long.byte 0x0 13.--17. 0x1 0x0 " fault_iout_oc_warn_cnt    ,Output over current warning count.  Defines the number of consecutive switching cycles (Tsw) the low pass filtered current must exceed the warn threshold in order to assert a warning."
    textline "                   "
    hexmask.long.byte 0x0 18.--22. 0x1 0x0 " fault_mfr_iout_oc_fast_c? ,MFR_IOUT_OC_FAST over current fault count.  Defines the number of consecutive switching cycles (Tsw) the cycle averaged current must exceed the fault threshold in order to assert a fault."
    textline "                   "
    hexmask.long.byte 0x0 23.--27. 0x1 0x0 " fault_iout_uc_fault_cnt   ,Output under current fault count.  Defines the number of consecutive switching cycles (Tsw) the cycle averaged current must exceed the fault threshold in order to assert a fault."

; ------------------ FAULT_CNT_VIN_IIN member of fault ------------------

  group 0x0004++0x0003
    line.long 0x000 "FAULT_CNT_VIN_IIN, Input over voltage fault count.  Defines the number of consecutive switching cycles (Tsw) the input voltage must exceed the fault threshold in order to assert a fault. "
    textline "                   "
    hexmask.long.byte 0x0 0.--1. 0x1 0x0 " fault_vin_ov_fault_cnt    ,Input over voltage fault count.  Defines the number of consecutive switching cycles (Tsw) the input voltage must exceed the fault threshold in order to assert a fault. "
    textline "                   "
    hexmask.long.byte 0x0 2.--3. 0x1 0x0 " fault_vin_ov_warn_cnt     ,Input over voltage warning count.  Defines the number of consecutive switching cycles (Tsw) the input voltage must exceed the warn threshold in order to assert a warning "
    textline "                   "
    hexmask.long.byte 0x0 4.--5. 0x1 0x0 " fault_vin_uv_fault_cnt    ,Input under voltage fault count.  Defines the number of consecutive switching cycles (Tsw) the input voltage must exceed the fault threshold in order to assert a fault. "
    textline "                   "
    hexmask.long.byte 0x0 6.--7. 0x1 0x0 " fault_vin_uv_warn_cnt     ,Input under voltage warning count.  Defines the number of consecutive switching cycles (Tsw) the input voltage must exceed the warn threshold in order to assert a warning "
    textline "                   "
    hexmask.long.byte 0x0 8.--12. 0x1 0x0 " fault_iin_oc_fault_cnt    ,Input over current fault count.  Defines the number of consecutive switching cycles (Tsw) the low pass filtered input current must exceed the fault threshold in order to assert a fault."
    textline "                   "
    hexmask.long.byte 0x0 13.--17. 0x1 0x0 " fault_iin_oc_warn_cnt     ,Input over current warning count.  Defines the number of consecutive switching cycles (Tsw) the low pass filtered input current must exceed the warn threshold in order to assert a warning"
    textline "                   "
    hexmask.long.byte 0x0 18.--23. 0x1 0x0 " fault_vin_fault_hyst      ,Input voltage (VIN) fault / warn deassertion hysteresis."

; ---------------------- FAULT_HYST member of fault ----------------------

  group 0x0008++0x0003
    line.long 0x000 "FAULT_HYST, Output voltage (VOUT) fault / warn deassertion hysteresis."
    textline "                   "
    hexmask.long.byte 0x0 0.--4. 0x1 0x0 " fault_vout_fault_hyst     ,Output voltage (VOUT) fault / warn deassertion hysteresis."
    textline "                   "
    hexmask.long.byte 0x0 5.--9. 0x1 0x0 " fault_iin_fault_hyst      ,Input current (IIN) fault / warn deassertion hysteresis."
    textline "                   "
    hexmask.long.byte 0x0 10.--15. 0x1 0x0 " fault_iout_oc_fault_hyst  ,Output over current (IOUT_OC) fault / warn deassertion hysteresis."
    textline "                   "
    hexmask.long.byte 0x0 16.--21. 0x1 0x0 " fault_iout_uc_fault_hyst  ,Output under current (IOUT_UC) fault / warn deassertion hysteresis."
    textline "                   "
    hexmask.long.byte 0x0 22.--26. 0x1 0x0 " fault_temp_fault_hyst     ,Temperature fault / warn deassertion hysteresis."

; ----------------- FAULT_SHUT_MASK_LOOP member of fault -----------------

  group 0x000C++0x0003
    line.long 0x000 "FAULT_SHUT_MASK_LO?, Shutdown mask for  Loop  faults.  Individual faults are enabled for shutdown when their corresponding bit is high.  Enabled faults disable the loop output and assert the shutdown interrupt immediately upon fault assertion. "
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " fault_shut_mask_loop      ,Shutdown mask for  Loop  faults.  Individual faults are enabled for shutdown when their corresponding bit is high.  Enabled faults disable the loop output and assert the shutdown interrupt immediately upon fault assertion. "

; ------------------ FAULT_T2_SHUT_MASK member of fault ------------------

  group 0x0010++0x0003
    line.long 0x000 "FAULT_T2_SHUT_MASK,  T2  shutdown mask for  Loop  faults.  Individual faults are enabled for T2 shutdown when their corresponding bit is high.  Enabled faults disable the loop output and assert the shutdown interrupt aligned with the T2 ramp time which typically aligns with the falling edge of the primary side PWM pulse.  Note that when corresponding bits in both fault_shut_mask_loop and fault_t2_shut_mask_loop are set to 1, the immediate shutdown behavior of fault_shut_mask_loop is implemented. "
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " fault_t2_shut_mask_loop   , T2  shutdown mask for  Loop  faults.  Individual faults are enabled for T2 shutdown when their corresponding bit is high.  Enabled faults disable the loop output and assert the shutdown interrupt aligned with the T2 ramp time which typically aligns with the falling edge of the primary side PWM pulse.  Note that when corresponding bits in both fault_shut_mask_loop and fault_t2_shut_mask_loop are set to 1, the immediate shutdown behavior of fault_shut_mask_loop is implemented. "

; ------------------ FAULT_ENABLE_LOOP member of fault ------------------

  group 0x0014++0x0003
    line.long 0x000 "FAULT_ENABLE_LOOP, Fault enable for  Loop  faults.  Individual faults are enabled for fault interrupt generation when their corresponding bit is high. "
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " fault_enable_loop         ,Fault enable for  Loop  faults.  Individual faults are enabled for fault interrupt generation when their corresponding bit is high. "

; ------------------ FAULT_VOUT_OV_FLT member of fault ------------------

  group 0x0018++0x0003
    line.long 0x000 "FAULT_VOUT_OV_FLT, Output over voltage fault threshold.  Note that this threshold is defined with respect to the voltage at the VSEN pin, after the vout sense resistor divider. Computed from PMBus command as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--9. 0x1 0x0 " fault_vout_ov_fault_thre? ,Output over voltage fault threshold.  Note that this threshold is defined with respect to the voltage at the VSEN pin, after the vout sense resistor divider. Computed from PMBus command as follows: "

; ------------------ FAULT_VOUT_OV_WRN member of fault ------------------

  group 0x001C++0x0003
    line.long 0x000 "FAULT_VOUT_OV_WRN, Output over voltage warning threshold.  Note that this threshold is defined with respect to the voltage at the VSEN pin, after the vout sense resistor divider. Computed from PMBus command as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--9. 0x1 0x0 " fault_vout_ov_warn_thresh ,Output over voltage warning threshold.  Note that this threshold is defined with respect to the voltage at the VSEN pin, after the vout sense resistor divider. Computed from PMBus command as follows: "

; ------------------ FAULT_VOUT_UV_FLT member of fault ------------------

  group 0x0020++0x0003
    line.long 0x000 "FAULT_VOUT_UV_FLT, Output under voltage fault threshold.  Note that this threshold is defined with respect to the voltage at the VSEN pin, after the vout sense resistor divider. Computed from PMBus command as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--9. 0x1 0x0 " fault_vout_uv_fault_thre? ,Output under voltage fault threshold.  Note that this threshold is defined with respect to the voltage at the VSEN pin, after the vout sense resistor divider. Computed from PMBus command as follows: "

; ------------------ FAULT_VOUT_UV_WRN member of fault ------------------

  group 0x0024++0x0003
    line.long 0x000 "FAULT_VOUT_UV_WRN, Output under voltage warning threshold.  Note that this threshold is defined with respect to the voltage at the VSEN pin, after the vout sense resistor divider. Computed from PMBus command as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--9. 0x1 0x0 " fault_vout_uv_warn_thresh ,Output under voltage warning threshold.  Note that this threshold is defined with respect to the voltage at the VSEN pin, after the vout sense resistor divider. Computed from PMBus command as follows: "

; ------------------- FAULT_VIN_OV_FLT member of fault -------------------

  group 0x0028++0x0003
    line.long 0x000 "FAULT_VIN_OV_FLT, Input over voltage fault threshold. Computed from PMBus command as follows:   fault_vin_ovp_fault_thresh(U7.3) = (VIN_OV_FAULT_LIMIT(U7.3)*2^-3 "
    textline "                   "
    hexmask.long.word 0x0 0.--9. 0x1 0x0 " fault_vin_ov_fault_thresh ,Input over voltage fault threshold. Computed from PMBus command as follows:   fault_vin_ovp_fault_thresh(U7.3) = (VIN_OV_FAULT_LIMIT(U7.3)*2^-3 "

; ------------------- FAULT_VIN_OV_WRN member of fault -------------------

  group 0x002C++0x0003
    line.long 0x000 "FAULT_VIN_OV_WRN, Input over voltage warning threshold. Computed from PMBus command as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--9. 0x1 0x0 " fault_vin_ov_warn_thresh  ,Input over voltage warning threshold. Computed from PMBus command as follows: "

; ------------------- FAULT_VIN_UV_FLT member of fault -------------------

  group 0x0030++0x0003
    line.long 0x000 "FAULT_VIN_UV_FLT, Input under voltage fault threshold. Computed from PMBus command as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--9. 0x1 0x0 " fault_vin_uv_fault_thresh ,Input under voltage fault threshold. Computed from PMBus command as follows: "

; ------------------- FAULT_VIN_UV_WRN member of fault -------------------

  group 0x0034++0x0003
    line.long 0x000 "FAULT_VIN_UV_WRN, Input under voltage warning threshold. Computed from PMBus command as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--9. 0x1 0x0 " fault_vin_uv_warn_thresh  ,Input under voltage warning threshold. Computed from PMBus command as follows: "

; ------------------ FAULT_IOUT_OC_FLT member of fault ------------------

  group 0x0038++0x0003
    line.long 0x000 "FAULT_IOUT_OC_FLT, Output over current fault threshold Computed from PMBus command as follows: "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " fault_iout_oc_fault_thre? ,Output over current fault threshold Computed from PMBus command as follows: "

; ------------------ FAULT_IOUT_LV_FLT member of fault ------------------

  group 0x003C++0x0003
    line.long 0x000 "FAULT_IOUT_LV_FLT, Output over current low voltage fault threshold.  Note that this threshold is defined with respect to the voltage at the VSEN pin, after the vout sense resistor divider. Computed from PMBus command as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--9. 0x1 0x0 " fault_iout_oc_lv_fault_t? ,Output over current low voltage fault threshold.  Note that this threshold is defined with respect to the voltage at the VSEN pin, after the vout sense resistor divider. Computed from PMBus command as follows: "

; ------------------ FAULT_IOUT_OC_WRN member of fault ------------------

  group 0x0040++0x0003
    line.long 0x000 "FAULT_IOUT_OC_WRN, Output over current warn threshold. Computed from PMBus command as follows: "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " fault_iout_oc_warn_thresh ,Output over current warn threshold. Computed from PMBus command as follows: "

; ------------------ FAULT_IOUT_UC_FLT member of fault ------------------

  group 0x0044++0x0003
    line.long 0x000 "FAULT_IOUT_UC_FLT, Output under current fault threshold.  Fault asserted when the cycle averaged output current is below this threshold. Computed from PMBus command as follows: "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " fault_iout_uc_fault_thre? ,Output under current fault threshold.  Fault asserted when the cycle averaged output current is below this threshold. Computed from PMBus command as follows: "

; ------------------- FAULT_MFR_OC_FLT member of fault -------------------

  group 0x0048++0x0003
    line.long 0x000 "FAULT_MFR_OC_FLT, Fast output over current fault threshold. Computed from PMBus command as follows: "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " fault_mfr_iout_oc_fast_t? ,Fast output over current fault threshold. Computed from PMBus command as follows: "

; ------------------- FAULT_IIN_OC_FLT member of fault -------------------

  group 0x004C++0x0003
    line.long 0x000 "FAULT_IIN_OC_FLT, Input over current fault threshold. Computed from PMBus command as follows: "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " fault_iin_oc_fault_thresh ,Input over current fault threshold. Computed from PMBus command as follows: "

; ------------------- FAULT_IIN_OC_WRN member of fault -------------------

  group 0x0050++0x0003
    line.long 0x000 "FAULT_IIN_OC_WRN, Input over current warning threshold. Computed from PMBus command as follows: "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " fault_iin_oc_warn_thresh  ,Input over current warning threshold. Computed from PMBus command as follows: "

; --------------------- FAULT_OT_FLT member of fault ---------------------

  group 0x0054++0x0003
    line.long 0x000 "FAULT_OT_FLT, Over temperature fault threshold in Telemetry Sense ADC codes.  Note that the ADC Code to Temperature lookup table is implemented in FW."
    textline "                   "
    hexmask.long.word 0x0 0.--9. 0x1 0x0 " fault_ot_fault_thresh     ,Over temperature fault threshold in Telemetry Sense ADC codes.  Note that the ADC Code to Temperature lookup table is implemented in FW."

; --------------------- FAULT_OT_WRN member of fault ---------------------

  group 0x0058++0x0003
    line.long 0x000 "FAULT_OT_WRN, Over temperature warn threshold in Telemetry Sense ADC codes.  Note that the ADC Code to Temperature lookup table is implemented in FW."
    textline "                   "
    hexmask.long.word 0x0 0.--9. 0x1 0x0 " fault_ot_warn_thresh      ,Over temperature warn threshold in Telemetry Sense ADC codes.  Note that the ADC Code to Temperature lookup table is implemented in FW."

; --------------------- FAULT_UT_FLT member of fault ---------------------

  group 0x005C++0x0003
    line.long 0x000 "FAULT_UT_FLT, Under temperature fault threshold in Telemetry Sense ADC codes.  Note that the ADC Code to Temperature lookup table is implemented in FW."
    textline "                   "
    hexmask.long.word 0x0 0.--9. 0x1 0x0 " fault_ut_fault_thresh     ,Under temperature fault threshold in Telemetry Sense ADC codes.  Note that the ADC Code to Temperature lookup table is implemented in FW."

; --------------------- FAULT_UT_WRN member of fault ---------------------

  group 0x0060++0x0003
    line.long 0x000 "FAULT_UT_WRN, Under temperature warn threshold in Telemetry Sense ADC codes.  Note that the ADC Code to Temperature lookup table is implemented in FW."
    textline "                   "
    hexmask.long.word 0x0 0.--9. 0x1 0x0 " fault_ut_warn_thresh      ,Under temperature warn threshold in Telemetry Sense ADC codes.  Note that the ADC Code to Temperature lookup table is implemented in FW."

; --------------------- FAULT_OT_SRC member of fault ---------------------

  group 0x0064++0x0003
    line.long 0x000 "FAULT_OT_SRC, Loop temperature source select. "
    textline "                   "
    hexmask.long.byte 0x0 0.--2. 0x1 0x0 " fault_temp_src_sel        ,Loop temperature source select. "

; ----------------- FAULT_SHUT_CLR_LOOP member of fault -----------------

  group 0x0068++0x0003
    line.long 0x000 "FAULT_SHUT_CLR_LOOP, Clears shutdown faults in fault_reg_loop when set high. This field should not be written until after FW has completed shutdown related cleanup (e.g., Vcontrol target returned to 0, appropriate blocks disabled)."
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " fault_shut_clr_loop       ,Clears shutdown faults in fault_reg_loop when set high. This field should not be written until after FW has completed shutdown related cleanup (e.g., Vcontrol target returned to 0, appropriate blocks disabled)."

; ----------------- FAULT_POLARITY_LOOP member of fault -----------------

  group 0x006C++0x0003
    line.long 0x000 "FAULT_POLARITY_LOOP, Defines the polarity of the fault with respect to the threshold.  When set to 0, the fault / warning is asserted using its default polarity (e.g.,  over  type fault asserted when above the threshold).  When set to 1, the fault / warning is asserted with the inverse to its default polarity (e.g.,  over  type fault asserted when below the threshold).  The inverse polarity may be used to generate an interrupt when a parameter no longer exceeds its fault / warning threshold. "
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " fault_polarity_loop       ,Defines the polarity of the fault with respect to the threshold.  When set to 0, the fault / warning is asserted using its default polarity (e.g.,  over  type fault asserted when above the threshold).  When set to 1, the fault / warning is asserted with the inverse to its default polarity (e.g.,  over  type fault asserted when below the threshold).  The inverse polarity may be used to generate an interrupt when a parameter no longer exceeds its fault / warning threshold. "

; ------------------- FAULT_FORCE_LOOP member of fault -------------------

  group 0x0070++0x0003
    line.long 0x000 "FAULT_FORCE_LOOP, Fault force set register.  When the bit corresponding to a fault / warning is set to 1, that fault / warning is asserted as if it had exceeded its threshold. "
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " fault_force_loop          ,Fault force set register.  When the bit corresponding to a fault / warning is set to 1, that fault / warning is asserted as if it had exceeded its threshold. "

; ------------------- FAULT_CLEAR_LOOP member of fault -------------------

  group 0x0074++0x0003
    line.long 0x000 "FAULT_CLEAR_LOOP, Fault force clear register.  When the bit corresponding to a fault / warning is set to 1, that fault / warning is cleared in the fault_status_loop and fault_ref_loop registers. "
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " fault_clear_loop          ,Fault force clear register.  When the bit corresponding to a fault / warning is set to 1, that fault / warning is cleared in the fault_status_loop and fault_ref_loop registers. "

; ------------------ FAULT_STATUS_LOOP member of fault ------------------

  rgroup 0x0078++0x0003
    line.long 0x000 "FAULT_STATUS_LOOP, Fault status register generated by sub-sampling fault_reg_loop at 2MHz.  Fault interrupts are generated from this register.  Once a fault bit is set it is latched in this register and can only be cleared via fault_clear_loop. "
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " fault_status_loop         ,Fault status register generated by sub-sampling fault_reg_loop at 2MHz.  Fault interrupts are generated from this register.  Once a fault bit is set it is latched in this register and can only be cleared via fault_clear_loop. "

; -------------------- FAULT_REG_LOOP member of fault --------------------

  rgroup 0x007C++0x0003
    line.long 0x000 "FAULT_REG_LOOP, Fault status register updated at 50MHz.  Once a fault bit is set it is latched in this register and can only be cleared via fault_clear_loop. "
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " fault_reg_loop            ,Fault status register updated at 50MHz.  Once a fault bit is set it is latched in this register and can only be cleared via fault_clear_loop. "

; ------------------- FAULT_IOUT_CC_RD member of fault -------------------

  rgroup 0x0080++0x0003
    line.long 0x000 "FAULT_IOUT_CC_RD, Status flag indicating constant current mode. "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " fault_iout_cc_mode        ,Status flag indicating constant current mode. "
    textline "                   "
    hexmask.long.word 0x0 1.--14. 0x1 0x0 " fault_iout_cc_adj         ,Status register indicating magnitude of constant current mode output voltage adjustment referenced to the VSEN pin (i.e., after the Vout sense resistor divider)."

; ------------------ FAULT_IOUT_CC_SEL member of fault ------------------

  group 0x0084++0x0003
    line.long 0x000 "FAULT_IOUT_CC_SEL, Constant current mode enable for IOUT_OC_FAULT.  Set by IOUT_OC_FAULT_RESPONSE. "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " fault_iout_cc_en          ,Constant current mode enable for IOUT_OC_FAULT.  Set by IOUT_OC_FAULT_RESPONSE. "
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " fault_iout_cc_en_fast     ,Constant current mode enable for MFR_IOUT_OC_FAST_FAULT.  Set by MFR_IOUT_OC_FAST_FAULT_RESPONSE. "

tree.end

; -------------------------------------------------------------------
; End Block - fault
; -------------------------------------------------------------------
tree.end
; @file:      faultcom.per
; Chip name:  SHASTA
; Module:     faultcom
; 
; Generated by the pmm metagen library.
;
; ===================================================================
; Copyright (C) 2018 Infineon Technologies AG
; All rights reserved.
; ===================================================================
;
; ===================================================================
; This document contains proprietary information. Passing on and
; copying of this document, and communication of its contents is not
; permitted without prior written authorisation.
; ===================================================================

; This file is automatically generated. Do not edit!


config 32. 8.
width 20.

tree "Block - faultcom"
; -------------------------------------------------------------------
; Begin Block - faultcom
; -------------------------------------------------------------------
base D:0x70005400

tree "faultcom"
; ---------------- FAULT_SHUT_MASK_COM member of faultcom ----------------

  group 0x0000++0x0003
    line.long 0x000 "FAULT_SHUT_MASK_COM, Shutdown mask for  Common  faults.  Individual faults are enabled for shutdown when their corresponding bit is high.  Enabled faults disable both loop outputs and assert the shutdown interrupt. "
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " fault_shut_mask_com       ,Shutdown mask for  Common  faults.  Individual faults are enabled for shutdown when their corresponding bit is high.  Enabled faults disable both loop outputs and assert the shutdown interrupt. "

; ---------------- FAULT_BLOCK_ON_SHUT member of faultcom ----------------

  group 0x0004++0x0003
    line.long 0x000 "FAULT_BLOCK_ON_SHUT, Defines whether faults continued to be reported after an initial shutdown fault has occurred and triggered shutdown. "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " fault_block_on_shut       ,Defines whether faults continued to be reported after an initial shutdown fault has occurred and triggered shutdown. "

; ----------------- FAULT_ENABLE_COM member of faultcom -----------------

  group 0x0008++0x0003
    line.long 0x000 "FAULT_ENABLE_COM, Fault enable for  Common  faults.  Individual faults are enabled for fault interrupt generation when their corresponding bit is high. "
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " fault_enable_com          ,Fault enable for  Common  faults.  Individual faults are enabled for fault interrupt generation when their corresponding bit is high. "

; ---------------- FAULT_SHUT_CLR_ALL member of faultcom ----------------

  group 0x000C++0x0003
    line.long 0x000 "FAULT_SHUT_CLR_ALL, Clears shutdown faults in fault_reg_com and both fault_reg_loop registers when high.  This field should not be written until after FW has completed shutdown related cleanup (e.g., Vcontrol target returned to 0, appropriate blocks disabled)."
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " fault_shut_clr_all        ,Clears shutdown faults in fault_reg_com and both fault_reg_loop registers when high.  This field should not be written until after FW has completed shutdown related cleanup (e.g., Vcontrol target returned to 0, appropriate blocks disabled)."

; ---------------- FAULT_SHUT_CLR_COM member of faultcom ----------------

  group 0x0010++0x0003
    line.long 0x000 "FAULT_SHUT_CLR_COM, Clears shutdown faults in fault_reg_com when set high. This field should not be written until after FW has completed shutdown related cleanup (e.g., Vcontrol target returned to 0, appropriate blocks disabled)."
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " fault_shut_clr_com        ,Clears shutdown faults in fault_reg_com when set high. This field should not be written until after FW has completed shutdown related cleanup (e.g., Vcontrol target returned to 0, appropriate blocks disabled)."

; ---------------- FAULT_SHUT_IRQ_BUS member of faultcom ----------------

  rgroup 0x0014++0x0003
    line.long 0x000 "FAULT_SHUT_IRQ_BUS, Shutdown interrupt (IRQ) status "
    textline "                   "
    hexmask.long.byte 0x0 0.--2. 0x1 0x0 " fault_shut_bus            ,Shutdown interrupt (IRQ) status "
    textline "                   "
    hexmask.long.byte 0x0 3.--5. 0x1 0x0 " fault_irq_bus             ,Fault interrupt (IRQ) status "

; ------------------ FAULT_FORCE_COM member of faultcom ------------------

  group 0x0018++0x0003
    line.long 0x000 "FAULT_FORCE_COM, Fault force set register.  When the bit corresponding to a fault / warning is set to 1, that fault / warning is asserted as if it had exceeded its threshold. "
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " fault_force_com           ,Fault force set register.  When the bit corresponding to a fault / warning is set to 1, that fault / warning is asserted as if it had exceeded its threshold. "

; ------------------ FAULT_CLEAR_COM member of faultcom ------------------

  group 0x001C++0x0003
    line.long 0x000 "FAULT_CLEAR_COM, Fault force clear register.  When the bit corresponding to a fault / warning is set to 1, that fault / warning is cleared in the fault_status_loop and fault_ref_loop registers. "
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " fault_clear_com           ,Fault force clear register.  When the bit corresponding to a fault / warning is set to 1, that fault / warning is cleared in the fault_status_loop and fault_ref_loop registers. "

; ----------------- FAULT_STATUS_COM member of faultcom -----------------

  rgroup 0x0020++0x0003
    line.long 0x000 "FAULT_STATUS_COM, Fault status register generated by sub-sampling fault_reg_com at 2MHz.  Fault interrupts are generated from this register.  Once a fault bit is set it is latched in this register and can only be cleared via fault_clear_com. "
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " fault_status_com          ,Fault status register generated by sub-sampling fault_reg_com at 2MHz.  Fault interrupts are generated from this register.  Once a fault bit is set it is latched in this register and can only be cleared via fault_clear_com. "

; ------------------- FAULT_ENCODE member of faultcom -------------------

  rgroup 0x0024++0x0003
    line.long 0x000 "FAULT_ENCODE, Priority encoding of the word {fault_status_com[31:0],fault1_status_loop[31:0],fault0_status_loop[31:0]} with fault_encode indicating the position of the first '1' searching from the LSB.  Fault0_status_loop[31:0] reports in the range 0-31, fault1_status_loop[31:0] reports ins the range 32-63 and fault_status_com[31:0] reports in the range 224-255."
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " fault_encode              ,Priority encoding of the word {fault_status_com[31:0],fault1_status_loop[31:0],fault0_status_loop[31:0]} with fault_encode indicating the position of the first '1' searching from the LSB.  Fault0_status_loop[31:0] reports in the range 0-31, fault1_status_loop[31:0] reports ins the range 32-63 and fault_status_com[31:0] reports in the range 224-255."

; ------------------- FAULT_REG_COM member of faultcom -------------------

  rgroup 0x0028++0x0003
    line.long 0x000 "FAULT_REG_COM, Fault status register updated at 50MHz.  Once a fault bit is set it is latched in this register and can only be cleared via fault_clear_com. "
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " fault_reg_com             ,Fault status register updated at 50MHz.  Once a fault bit is set it is latched in this register and can only be cleared via fault_clear_com. "

tree.end

; -------------------------------------------------------------------
; End Block - faultcom
; -------------------------------------------------------------------
tree.end
; @file:      gpio.per
; Chip name:  SHASTA
; Module:     gpio
; 
; Generated by the pmm metagen library.
;
; ===================================================================
; Copyright (C) 2018 Infineon Technologies AG
; All rights reserved.
; ===================================================================
;
; ===================================================================
; This document contains proprietary information. Passing on and
; copying of this document, and communication of its contents is not
; permitted without prior written authorisation.
; ===================================================================

; This file is automatically generated. Do not edit!


config 32. 8.
width 20.

tree "Block - gpio"
; -------------------------------------------------------------------
; Begin Block - gpio
; -------------------------------------------------------------------
base D:0x60040000

tree "gpio_0"
; ----------------------- GPIODATA member of gpio -----------------------

  group 0x0000++0x0003
    line.long 0x000 "GPIODATA #0, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0004++0x0003
    line.long 0x000 "GPIODATA #1, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0008++0x0003
    line.long 0x000 "GPIODATA #2, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x000C++0x0003
    line.long 0x000 "GPIODATA #3, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0010++0x0003
    line.long 0x000 "GPIODATA #4, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0014++0x0003
    line.long 0x000 "GPIODATA #5, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0018++0x0003
    line.long 0x000 "GPIODATA #6, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x001C++0x0003
    line.long 0x000 "GPIODATA #7, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0020++0x0003
    line.long 0x000 "GPIODATA #8, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0024++0x0003
    line.long 0x000 "GPIODATA #9, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0028++0x0003
    line.long 0x000 "GPIODATA #10, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x002C++0x0003
    line.long 0x000 "GPIODATA #11, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0030++0x0003
    line.long 0x000 "GPIODATA #12, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0034++0x0003
    line.long 0x000 "GPIODATA #13, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0038++0x0003
    line.long 0x000 "GPIODATA #14, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x003C++0x0003
    line.long 0x000 "GPIODATA #15, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0040++0x0003
    line.long 0x000 "GPIODATA #16, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0044++0x0003
    line.long 0x000 "GPIODATA #17, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0048++0x0003
    line.long 0x000 "GPIODATA #18, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x004C++0x0003
    line.long 0x000 "GPIODATA #19, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0050++0x0003
    line.long 0x000 "GPIODATA #20, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0054++0x0003
    line.long 0x000 "GPIODATA #21, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0058++0x0003
    line.long 0x000 "GPIODATA #22, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x005C++0x0003
    line.long 0x000 "GPIODATA #23, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0060++0x0003
    line.long 0x000 "GPIODATA #24, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0064++0x0003
    line.long 0x000 "GPIODATA #25, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0068++0x0003
    line.long 0x000 "GPIODATA #26, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x006C++0x0003
    line.long 0x000 "GPIODATA #27, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0070++0x0003
    line.long 0x000 "GPIODATA #28, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0074++0x0003
    line.long 0x000 "GPIODATA #29, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0078++0x0003
    line.long 0x000 "GPIODATA #30, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x007C++0x0003
    line.long 0x000 "GPIODATA #31, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0080++0x0003
    line.long 0x000 "GPIODATA #32, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0084++0x0003
    line.long 0x000 "GPIODATA #33, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0088++0x0003
    line.long 0x000 "GPIODATA #34, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x008C++0x0003
    line.long 0x000 "GPIODATA #35, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0090++0x0003
    line.long 0x000 "GPIODATA #36, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0094++0x0003
    line.long 0x000 "GPIODATA #37, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0098++0x0003
    line.long 0x000 "GPIODATA #38, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x009C++0x0003
    line.long 0x000 "GPIODATA #39, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x00A0++0x0003
    line.long 0x000 "GPIODATA #40, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x00A4++0x0003
    line.long 0x000 "GPIODATA #41, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x00A8++0x0003
    line.long 0x000 "GPIODATA #42, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x00AC++0x0003
    line.long 0x000 "GPIODATA #43, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x00B0++0x0003
    line.long 0x000 "GPIODATA #44, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x00B4++0x0003
    line.long 0x000 "GPIODATA #45, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x00B8++0x0003
    line.long 0x000 "GPIODATA #46, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x00BC++0x0003
    line.long 0x000 "GPIODATA #47, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x00C0++0x0003
    line.long 0x000 "GPIODATA #48, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x00C4++0x0003
    line.long 0x000 "GPIODATA #49, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x00C8++0x0003
    line.long 0x000 "GPIODATA #50, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x00CC++0x0003
    line.long 0x000 "GPIODATA #51, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x00D0++0x0003
    line.long 0x000 "GPIODATA #52, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x00D4++0x0003
    line.long 0x000 "GPIODATA #53, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x00D8++0x0003
    line.long 0x000 "GPIODATA #54, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x00DC++0x0003
    line.long 0x000 "GPIODATA #55, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x00E0++0x0003
    line.long 0x000 "GPIODATA #56, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x00E4++0x0003
    line.long 0x000 "GPIODATA #57, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x00E8++0x0003
    line.long 0x000 "GPIODATA #58, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x00EC++0x0003
    line.long 0x000 "GPIODATA #59, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x00F0++0x0003
    line.long 0x000 "GPIODATA #60, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x00F4++0x0003
    line.long 0x000 "GPIODATA #61, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x00F8++0x0003
    line.long 0x000 "GPIODATA #62, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x00FC++0x0003
    line.long 0x000 "GPIODATA #63, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0100++0x0003
    line.long 0x000 "GPIODATA #64, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0104++0x0003
    line.long 0x000 "GPIODATA #65, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0108++0x0003
    line.long 0x000 "GPIODATA #66, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x010C++0x0003
    line.long 0x000 "GPIODATA #67, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0110++0x0003
    line.long 0x000 "GPIODATA #68, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0114++0x0003
    line.long 0x000 "GPIODATA #69, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0118++0x0003
    line.long 0x000 "GPIODATA #70, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x011C++0x0003
    line.long 0x000 "GPIODATA #71, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0120++0x0003
    line.long 0x000 "GPIODATA #72, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0124++0x0003
    line.long 0x000 "GPIODATA #73, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0128++0x0003
    line.long 0x000 "GPIODATA #74, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x012C++0x0003
    line.long 0x000 "GPIODATA #75, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0130++0x0003
    line.long 0x000 "GPIODATA #76, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0134++0x0003
    line.long 0x000 "GPIODATA #77, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0138++0x0003
    line.long 0x000 "GPIODATA #78, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x013C++0x0003
    line.long 0x000 "GPIODATA #79, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0140++0x0003
    line.long 0x000 "GPIODATA #80, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0144++0x0003
    line.long 0x000 "GPIODATA #81, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0148++0x0003
    line.long 0x000 "GPIODATA #82, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x014C++0x0003
    line.long 0x000 "GPIODATA #83, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0150++0x0003
    line.long 0x000 "GPIODATA #84, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0154++0x0003
    line.long 0x000 "GPIODATA #85, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0158++0x0003
    line.long 0x000 "GPIODATA #86, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x015C++0x0003
    line.long 0x000 "GPIODATA #87, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0160++0x0003
    line.long 0x000 "GPIODATA #88, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0164++0x0003
    line.long 0x000 "GPIODATA #89, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0168++0x0003
    line.long 0x000 "GPIODATA #90, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x016C++0x0003
    line.long 0x000 "GPIODATA #91, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0170++0x0003
    line.long 0x000 "GPIODATA #92, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0174++0x0003
    line.long 0x000 "GPIODATA #93, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0178++0x0003
    line.long 0x000 "GPIODATA #94, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x017C++0x0003
    line.long 0x000 "GPIODATA #95, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0180++0x0003
    line.long 0x000 "GPIODATA #96, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0184++0x0003
    line.long 0x000 "GPIODATA #97, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0188++0x0003
    line.long 0x000 "GPIODATA #98, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x018C++0x0003
    line.long 0x000 "GPIODATA #99, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0190++0x0003
    line.long 0x000 "GPIODATA #100, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0194++0x0003
    line.long 0x000 "GPIODATA #101, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0198++0x0003
    line.long 0x000 "GPIODATA #102, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x019C++0x0003
    line.long 0x000 "GPIODATA #103, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x01A0++0x0003
    line.long 0x000 "GPIODATA #104, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x01A4++0x0003
    line.long 0x000 "GPIODATA #105, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x01A8++0x0003
    line.long 0x000 "GPIODATA #106, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x01AC++0x0003
    line.long 0x000 "GPIODATA #107, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x01B0++0x0003
    line.long 0x000 "GPIODATA #108, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x01B4++0x0003
    line.long 0x000 "GPIODATA #109, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x01B8++0x0003
    line.long 0x000 "GPIODATA #110, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x01BC++0x0003
    line.long 0x000 "GPIODATA #111, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x01C0++0x0003
    line.long 0x000 "GPIODATA #112, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x01C4++0x0003
    line.long 0x000 "GPIODATA #113, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x01C8++0x0003
    line.long 0x000 "GPIODATA #114, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x01CC++0x0003
    line.long 0x000 "GPIODATA #115, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x01D0++0x0003
    line.long 0x000 "GPIODATA #116, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x01D4++0x0003
    line.long 0x000 "GPIODATA #117, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x01D8++0x0003
    line.long 0x000 "GPIODATA #118, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x01DC++0x0003
    line.long 0x000 "GPIODATA #119, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x01E0++0x0003
    line.long 0x000 "GPIODATA #120, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x01E4++0x0003
    line.long 0x000 "GPIODATA #121, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x01E8++0x0003
    line.long 0x000 "GPIODATA #122, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x01EC++0x0003
    line.long 0x000 "GPIODATA #123, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x01F0++0x0003
    line.long 0x000 "GPIODATA #124, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x01F4++0x0003
    line.long 0x000 "GPIODATA #125, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x01F8++0x0003
    line.long 0x000 "GPIODATA #126, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x01FC++0x0003
    line.long 0x000 "GPIODATA #127, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0200++0x0003
    line.long 0x000 "GPIODATA #128, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0204++0x0003
    line.long 0x000 "GPIODATA #129, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0208++0x0003
    line.long 0x000 "GPIODATA #130, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x020C++0x0003
    line.long 0x000 "GPIODATA #131, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0210++0x0003
    line.long 0x000 "GPIODATA #132, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0214++0x0003
    line.long 0x000 "GPIODATA #133, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0218++0x0003
    line.long 0x000 "GPIODATA #134, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x021C++0x0003
    line.long 0x000 "GPIODATA #135, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0220++0x0003
    line.long 0x000 "GPIODATA #136, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0224++0x0003
    line.long 0x000 "GPIODATA #137, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0228++0x0003
    line.long 0x000 "GPIODATA #138, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x022C++0x0003
    line.long 0x000 "GPIODATA #139, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0230++0x0003
    line.long 0x000 "GPIODATA #140, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0234++0x0003
    line.long 0x000 "GPIODATA #141, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0238++0x0003
    line.long 0x000 "GPIODATA #142, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x023C++0x0003
    line.long 0x000 "GPIODATA #143, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0240++0x0003
    line.long 0x000 "GPIODATA #144, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0244++0x0003
    line.long 0x000 "GPIODATA #145, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0248++0x0003
    line.long 0x000 "GPIODATA #146, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x024C++0x0003
    line.long 0x000 "GPIODATA #147, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0250++0x0003
    line.long 0x000 "GPIODATA #148, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0254++0x0003
    line.long 0x000 "GPIODATA #149, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0258++0x0003
    line.long 0x000 "GPIODATA #150, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x025C++0x0003
    line.long 0x000 "GPIODATA #151, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0260++0x0003
    line.long 0x000 "GPIODATA #152, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0264++0x0003
    line.long 0x000 "GPIODATA #153, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0268++0x0003
    line.long 0x000 "GPIODATA #154, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x026C++0x0003
    line.long 0x000 "GPIODATA #155, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0270++0x0003
    line.long 0x000 "GPIODATA #156, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0274++0x0003
    line.long 0x000 "GPIODATA #157, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0278++0x0003
    line.long 0x000 "GPIODATA #158, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x027C++0x0003
    line.long 0x000 "GPIODATA #159, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0280++0x0003
    line.long 0x000 "GPIODATA #160, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0284++0x0003
    line.long 0x000 "GPIODATA #161, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0288++0x0003
    line.long 0x000 "GPIODATA #162, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x028C++0x0003
    line.long 0x000 "GPIODATA #163, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0290++0x0003
    line.long 0x000 "GPIODATA #164, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0294++0x0003
    line.long 0x000 "GPIODATA #165, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0298++0x0003
    line.long 0x000 "GPIODATA #166, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x029C++0x0003
    line.long 0x000 "GPIODATA #167, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x02A0++0x0003
    line.long 0x000 "GPIODATA #168, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x02A4++0x0003
    line.long 0x000 "GPIODATA #169, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x02A8++0x0003
    line.long 0x000 "GPIODATA #170, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x02AC++0x0003
    line.long 0x000 "GPIODATA #171, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x02B0++0x0003
    line.long 0x000 "GPIODATA #172, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x02B4++0x0003
    line.long 0x000 "GPIODATA #173, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x02B8++0x0003
    line.long 0x000 "GPIODATA #174, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x02BC++0x0003
    line.long 0x000 "GPIODATA #175, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x02C0++0x0003
    line.long 0x000 "GPIODATA #176, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x02C4++0x0003
    line.long 0x000 "GPIODATA #177, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x02C8++0x0003
    line.long 0x000 "GPIODATA #178, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x02CC++0x0003
    line.long 0x000 "GPIODATA #179, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x02D0++0x0003
    line.long 0x000 "GPIODATA #180, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x02D4++0x0003
    line.long 0x000 "GPIODATA #181, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x02D8++0x0003
    line.long 0x000 "GPIODATA #182, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x02DC++0x0003
    line.long 0x000 "GPIODATA #183, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x02E0++0x0003
    line.long 0x000 "GPIODATA #184, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x02E4++0x0003
    line.long 0x000 "GPIODATA #185, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x02E8++0x0003
    line.long 0x000 "GPIODATA #186, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x02EC++0x0003
    line.long 0x000 "GPIODATA #187, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x02F0++0x0003
    line.long 0x000 "GPIODATA #188, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x02F4++0x0003
    line.long 0x000 "GPIODATA #189, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x02F8++0x0003
    line.long 0x000 "GPIODATA #190, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x02FC++0x0003
    line.long 0x000 "GPIODATA #191, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0300++0x0003
    line.long 0x000 "GPIODATA #192, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0304++0x0003
    line.long 0x000 "GPIODATA #193, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0308++0x0003
    line.long 0x000 "GPIODATA #194, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x030C++0x0003
    line.long 0x000 "GPIODATA #195, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0310++0x0003
    line.long 0x000 "GPIODATA #196, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0314++0x0003
    line.long 0x000 "GPIODATA #197, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0318++0x0003
    line.long 0x000 "GPIODATA #198, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x031C++0x0003
    line.long 0x000 "GPIODATA #199, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0320++0x0003
    line.long 0x000 "GPIODATA #200, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0324++0x0003
    line.long 0x000 "GPIODATA #201, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0328++0x0003
    line.long 0x000 "GPIODATA #202, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x032C++0x0003
    line.long 0x000 "GPIODATA #203, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0330++0x0003
    line.long 0x000 "GPIODATA #204, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0334++0x0003
    line.long 0x000 "GPIODATA #205, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0338++0x0003
    line.long 0x000 "GPIODATA #206, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x033C++0x0003
    line.long 0x000 "GPIODATA #207, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0340++0x0003
    line.long 0x000 "GPIODATA #208, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0344++0x0003
    line.long 0x000 "GPIODATA #209, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0348++0x0003
    line.long 0x000 "GPIODATA #210, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x034C++0x0003
    line.long 0x000 "GPIODATA #211, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0350++0x0003
    line.long 0x000 "GPIODATA #212, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0354++0x0003
    line.long 0x000 "GPIODATA #213, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0358++0x0003
    line.long 0x000 "GPIODATA #214, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x035C++0x0003
    line.long 0x000 "GPIODATA #215, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0360++0x0003
    line.long 0x000 "GPIODATA #216, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0364++0x0003
    line.long 0x000 "GPIODATA #217, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0368++0x0003
    line.long 0x000 "GPIODATA #218, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x036C++0x0003
    line.long 0x000 "GPIODATA #219, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0370++0x0003
    line.long 0x000 "GPIODATA #220, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0374++0x0003
    line.long 0x000 "GPIODATA #221, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0378++0x0003
    line.long 0x000 "GPIODATA #222, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x037C++0x0003
    line.long 0x000 "GPIODATA #223, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0380++0x0003
    line.long 0x000 "GPIODATA #224, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0384++0x0003
    line.long 0x000 "GPIODATA #225, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0388++0x0003
    line.long 0x000 "GPIODATA #226, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x038C++0x0003
    line.long 0x000 "GPIODATA #227, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0390++0x0003
    line.long 0x000 "GPIODATA #228, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0394++0x0003
    line.long 0x000 "GPIODATA #229, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0398++0x0003
    line.long 0x000 "GPIODATA #230, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x039C++0x0003
    line.long 0x000 "GPIODATA #231, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x03A0++0x0003
    line.long 0x000 "GPIODATA #232, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x03A4++0x0003
    line.long 0x000 "GPIODATA #233, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x03A8++0x0003
    line.long 0x000 "GPIODATA #234, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x03AC++0x0003
    line.long 0x000 "GPIODATA #235, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x03B0++0x0003
    line.long 0x000 "GPIODATA #236, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x03B4++0x0003
    line.long 0x000 "GPIODATA #237, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x03B8++0x0003
    line.long 0x000 "GPIODATA #238, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x03BC++0x0003
    line.long 0x000 "GPIODATA #239, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x03C0++0x0003
    line.long 0x000 "GPIODATA #240, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x03C4++0x0003
    line.long 0x000 "GPIODATA #241, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x03C8++0x0003
    line.long 0x000 "GPIODATA #242, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x03CC++0x0003
    line.long 0x000 "GPIODATA #243, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x03D0++0x0003
    line.long 0x000 "GPIODATA #244, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x03D4++0x0003
    line.long 0x000 "GPIODATA #245, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x03D8++0x0003
    line.long 0x000 "GPIODATA #246, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x03DC++0x0003
    line.long 0x000 "GPIODATA #247, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x03E0++0x0003
    line.long 0x000 "GPIODATA #248, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x03E4++0x0003
    line.long 0x000 "GPIODATA #249, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x03E8++0x0003
    line.long 0x000 "GPIODATA #250, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x03EC++0x0003
    line.long 0x000 "GPIODATA #251, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x03F0++0x0003
    line.long 0x000 "GPIODATA #252, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x03F4++0x0003
    line.long 0x000 "GPIODATA #253, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x03F8++0x0003
    line.long 0x000 "GPIODATA #254, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x03FC++0x0003
    line.long 0x000 "GPIODATA #255, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

; ------------------------ GPIODIR member of gpio ------------------------

  group 0x0400++0x0003
    line.long 0x000 "GPIODIR, Data Direction Register"
    textline "                   "
    bitfld.long 0x0 0.--7. " DIR                       ,Data Direction Control" "S0 (0),S1 (1),%x..."

; ------------------------ GPIOIS member of gpio ------------------------

  group 0x0404++0x0003
    line.long 0x000 "GPIOIS, Interrupt Sense Register"
    textline "                   "
    bitfld.long 0x0 0.--7. " INTSENSE                  ,Interrupt Sense Control" "S0 (0),S1 (1),%x..."

; ------------------------ GPIOIBE member of gpio ------------------------

  group 0x0408++0x0003
    line.long 0x000 "GPIOIBE, Interrupt Both-Edges Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " INTEDGE                   ,Interrupt Both-Edges Control"

; ------------------------ GPIOIEV member of gpio ------------------------

  group 0x040C++0x0003
    line.long 0x000 "GPIOIEV, Interrupt Event Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " INTEVENT                  ,Interrupt Event Control"

; ------------------------ GPIOIE member of gpio ------------------------

  group 0x0410++0x0003
    line.long 0x000 "GPIOIE, Interrupt Mask Register"
    textline "                   "
    bitfld.long 0x0 0.--7. " INTENA                    ,Interrupt Mask Control" "S0 (0),S1 (1),%x..."

; ------------------------ GPIORIS member of gpio ------------------------

  rgroup 0x0414++0x0003
    line.long 0x000 "GPIORIS, Raw Interrupt Status Register"
    textline "                   "
    bitfld.long 0x0 0.--7. " INTRAW                    ,Raw Interrupt Status" "S0 (0),S1 (1),%x..."

; ------------------------ GPIOMIS member of gpio ------------------------

  rgroup 0x0418++0x0003
    line.long 0x000 "GPIOMIS, Masked Interrupt Status Register"
    textline "                   "
    bitfld.long 0x0 0.--7. " INTMASK                   ,Masked Interrupt Status" "S0 (0),S1 (1),%x..."

; ------------------------ GPIOIC member of gpio ------------------------

  group 0x041C++0x0003
    line.long 0x000 "GPIOIC, Interrupt Clear Register"
    textline "                   "
    bitfld.long 0x0 0.--7. " INTCLR                    ,Interrupt Clear Control" "S0 (0),S1 (1),%x..."

; ----------------------- GPIOAFSEL member of gpio -----------------------

  group 0x0420++0x0003
    line.long 0x000 "GPIOAFSEL, Mode Control Select Register"
    textline "                   "
    bitfld.long 0x0 0.--7. " MSEL                      ,Mode Control Select" "S0 (0),S1 (1),%x..."

; --------------------- GPIOPeriphID0 member of gpio ---------------------

  rgroup 0x0FE0++0x0003
    line.long 0x000 "GPIOPeriphID0, GPIO Identification Register 0"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " PartNumber0               ,Part Number 0"

; --------------------- GPIOPeriphID1 member of gpio ---------------------

  rgroup 0x0FE4++0x0003
    line.long 0x000 "GPIOPeriphID1, GPIO Identification Register 1"
    textline "                   "
    hexmask.long.byte 0x0 0.--3. 0x1 0x0 " PartNumber1               ,Part Number 1"
    textline "                   "
    hexmask.long.byte 0x0 4.--7. 0x1 0x0 " Designer0                 ,Designer Number 0"

; --------------------- GPIOPeriphID2 member of gpio ---------------------

  rgroup 0x0FE8++0x0003
    line.long 0x000 "GPIOPeriphID2, GPIO Identification Register 2"
    textline "                   "
    hexmask.long.byte 0x0 0.--3. 0x1 0x0 " Designer1                 ,Designer Number 1"
    textline "                   "
    hexmask.long.byte 0x0 4.--7. 0x1 0x0 " Revision                  ,Revision Number"

; --------------------- GPIOPeriphID3 member of gpio ---------------------

  rgroup 0x0FEC++0x0003
    line.long 0x000 "GPIOPeriphID3, GPIO Identification Register 3"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " Configuration             ,Configuration Number"

; --------------------- GPIOPCellID0 member of gpio ---------------------

  rgroup 0x0FF0++0x0003
    line.long 0x000 "GPIOPCellID0, PrimeCell Identification Register 0"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " GPIOPCellID0              ,Cell Identification Number 0"

; --------------------- GPIOPCellID1 member of gpio ---------------------

  rgroup 0x0FF4++0x0003
    line.long 0x000 "GPIOPCellID1, PrimeCell Identification Register 1"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " GPIOPCellID1              ,Cell Identification Number 1"

; --------------------- GPIOPCellID2 member of gpio ---------------------

  rgroup 0x0FF8++0x0003
    line.long 0x000 "GPIOPCellID2, PrimeCell Identification Register 2"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " GPIOPCellID2              ,Cell Identification Number 2"

; --------------------- GPIOPCellID3 member of gpio ---------------------

  rgroup 0x0FFC++0x0003
    line.long 0x000 "GPIOPCellID3, PrimeCell Identification Register 3"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " GPIOPCellID3              ,Cell Identification Number 3"

tree.end
base D:0x60050000

tree "gpio_1"
; ----------------------- GPIODATA member of gpio -----------------------

  group 0x0000++0x0003
    line.long 0x000 "GPIODATA #0, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0004++0x0003
    line.long 0x000 "GPIODATA #1, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0008++0x0003
    line.long 0x000 "GPIODATA #2, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x000C++0x0003
    line.long 0x000 "GPIODATA #3, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0010++0x0003
    line.long 0x000 "GPIODATA #4, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0014++0x0003
    line.long 0x000 "GPIODATA #5, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0018++0x0003
    line.long 0x000 "GPIODATA #6, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x001C++0x0003
    line.long 0x000 "GPIODATA #7, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0020++0x0003
    line.long 0x000 "GPIODATA #8, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0024++0x0003
    line.long 0x000 "GPIODATA #9, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0028++0x0003
    line.long 0x000 "GPIODATA #10, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x002C++0x0003
    line.long 0x000 "GPIODATA #11, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0030++0x0003
    line.long 0x000 "GPIODATA #12, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0034++0x0003
    line.long 0x000 "GPIODATA #13, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0038++0x0003
    line.long 0x000 "GPIODATA #14, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x003C++0x0003
    line.long 0x000 "GPIODATA #15, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0040++0x0003
    line.long 0x000 "GPIODATA #16, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0044++0x0003
    line.long 0x000 "GPIODATA #17, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0048++0x0003
    line.long 0x000 "GPIODATA #18, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x004C++0x0003
    line.long 0x000 "GPIODATA #19, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0050++0x0003
    line.long 0x000 "GPIODATA #20, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0054++0x0003
    line.long 0x000 "GPIODATA #21, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0058++0x0003
    line.long 0x000 "GPIODATA #22, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x005C++0x0003
    line.long 0x000 "GPIODATA #23, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0060++0x0003
    line.long 0x000 "GPIODATA #24, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0064++0x0003
    line.long 0x000 "GPIODATA #25, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0068++0x0003
    line.long 0x000 "GPIODATA #26, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x006C++0x0003
    line.long 0x000 "GPIODATA #27, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0070++0x0003
    line.long 0x000 "GPIODATA #28, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0074++0x0003
    line.long 0x000 "GPIODATA #29, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0078++0x0003
    line.long 0x000 "GPIODATA #30, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x007C++0x0003
    line.long 0x000 "GPIODATA #31, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0080++0x0003
    line.long 0x000 "GPIODATA #32, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0084++0x0003
    line.long 0x000 "GPIODATA #33, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0088++0x0003
    line.long 0x000 "GPIODATA #34, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x008C++0x0003
    line.long 0x000 "GPIODATA #35, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0090++0x0003
    line.long 0x000 "GPIODATA #36, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0094++0x0003
    line.long 0x000 "GPIODATA #37, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0098++0x0003
    line.long 0x000 "GPIODATA #38, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x009C++0x0003
    line.long 0x000 "GPIODATA #39, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x00A0++0x0003
    line.long 0x000 "GPIODATA #40, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x00A4++0x0003
    line.long 0x000 "GPIODATA #41, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x00A8++0x0003
    line.long 0x000 "GPIODATA #42, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x00AC++0x0003
    line.long 0x000 "GPIODATA #43, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x00B0++0x0003
    line.long 0x000 "GPIODATA #44, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x00B4++0x0003
    line.long 0x000 "GPIODATA #45, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x00B8++0x0003
    line.long 0x000 "GPIODATA #46, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x00BC++0x0003
    line.long 0x000 "GPIODATA #47, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x00C0++0x0003
    line.long 0x000 "GPIODATA #48, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x00C4++0x0003
    line.long 0x000 "GPIODATA #49, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x00C8++0x0003
    line.long 0x000 "GPIODATA #50, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x00CC++0x0003
    line.long 0x000 "GPIODATA #51, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x00D0++0x0003
    line.long 0x000 "GPIODATA #52, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x00D4++0x0003
    line.long 0x000 "GPIODATA #53, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x00D8++0x0003
    line.long 0x000 "GPIODATA #54, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x00DC++0x0003
    line.long 0x000 "GPIODATA #55, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x00E0++0x0003
    line.long 0x000 "GPIODATA #56, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x00E4++0x0003
    line.long 0x000 "GPIODATA #57, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x00E8++0x0003
    line.long 0x000 "GPIODATA #58, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x00EC++0x0003
    line.long 0x000 "GPIODATA #59, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x00F0++0x0003
    line.long 0x000 "GPIODATA #60, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x00F4++0x0003
    line.long 0x000 "GPIODATA #61, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x00F8++0x0003
    line.long 0x000 "GPIODATA #62, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x00FC++0x0003
    line.long 0x000 "GPIODATA #63, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0100++0x0003
    line.long 0x000 "GPIODATA #64, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0104++0x0003
    line.long 0x000 "GPIODATA #65, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0108++0x0003
    line.long 0x000 "GPIODATA #66, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x010C++0x0003
    line.long 0x000 "GPIODATA #67, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0110++0x0003
    line.long 0x000 "GPIODATA #68, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0114++0x0003
    line.long 0x000 "GPIODATA #69, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0118++0x0003
    line.long 0x000 "GPIODATA #70, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x011C++0x0003
    line.long 0x000 "GPIODATA #71, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0120++0x0003
    line.long 0x000 "GPIODATA #72, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0124++0x0003
    line.long 0x000 "GPIODATA #73, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0128++0x0003
    line.long 0x000 "GPIODATA #74, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x012C++0x0003
    line.long 0x000 "GPIODATA #75, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0130++0x0003
    line.long 0x000 "GPIODATA #76, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0134++0x0003
    line.long 0x000 "GPIODATA #77, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0138++0x0003
    line.long 0x000 "GPIODATA #78, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x013C++0x0003
    line.long 0x000 "GPIODATA #79, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0140++0x0003
    line.long 0x000 "GPIODATA #80, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0144++0x0003
    line.long 0x000 "GPIODATA #81, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0148++0x0003
    line.long 0x000 "GPIODATA #82, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x014C++0x0003
    line.long 0x000 "GPIODATA #83, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0150++0x0003
    line.long 0x000 "GPIODATA #84, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0154++0x0003
    line.long 0x000 "GPIODATA #85, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0158++0x0003
    line.long 0x000 "GPIODATA #86, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x015C++0x0003
    line.long 0x000 "GPIODATA #87, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0160++0x0003
    line.long 0x000 "GPIODATA #88, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0164++0x0003
    line.long 0x000 "GPIODATA #89, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0168++0x0003
    line.long 0x000 "GPIODATA #90, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x016C++0x0003
    line.long 0x000 "GPIODATA #91, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0170++0x0003
    line.long 0x000 "GPIODATA #92, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0174++0x0003
    line.long 0x000 "GPIODATA #93, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0178++0x0003
    line.long 0x000 "GPIODATA #94, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x017C++0x0003
    line.long 0x000 "GPIODATA #95, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0180++0x0003
    line.long 0x000 "GPIODATA #96, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0184++0x0003
    line.long 0x000 "GPIODATA #97, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0188++0x0003
    line.long 0x000 "GPIODATA #98, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x018C++0x0003
    line.long 0x000 "GPIODATA #99, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0190++0x0003
    line.long 0x000 "GPIODATA #100, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0194++0x0003
    line.long 0x000 "GPIODATA #101, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0198++0x0003
    line.long 0x000 "GPIODATA #102, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x019C++0x0003
    line.long 0x000 "GPIODATA #103, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x01A0++0x0003
    line.long 0x000 "GPIODATA #104, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x01A4++0x0003
    line.long 0x000 "GPIODATA #105, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x01A8++0x0003
    line.long 0x000 "GPIODATA #106, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x01AC++0x0003
    line.long 0x000 "GPIODATA #107, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x01B0++0x0003
    line.long 0x000 "GPIODATA #108, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x01B4++0x0003
    line.long 0x000 "GPIODATA #109, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x01B8++0x0003
    line.long 0x000 "GPIODATA #110, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x01BC++0x0003
    line.long 0x000 "GPIODATA #111, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x01C0++0x0003
    line.long 0x000 "GPIODATA #112, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x01C4++0x0003
    line.long 0x000 "GPIODATA #113, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x01C8++0x0003
    line.long 0x000 "GPIODATA #114, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x01CC++0x0003
    line.long 0x000 "GPIODATA #115, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x01D0++0x0003
    line.long 0x000 "GPIODATA #116, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x01D4++0x0003
    line.long 0x000 "GPIODATA #117, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x01D8++0x0003
    line.long 0x000 "GPIODATA #118, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x01DC++0x0003
    line.long 0x000 "GPIODATA #119, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x01E0++0x0003
    line.long 0x000 "GPIODATA #120, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x01E4++0x0003
    line.long 0x000 "GPIODATA #121, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x01E8++0x0003
    line.long 0x000 "GPIODATA #122, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x01EC++0x0003
    line.long 0x000 "GPIODATA #123, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x01F0++0x0003
    line.long 0x000 "GPIODATA #124, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x01F4++0x0003
    line.long 0x000 "GPIODATA #125, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x01F8++0x0003
    line.long 0x000 "GPIODATA #126, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x01FC++0x0003
    line.long 0x000 "GPIODATA #127, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0200++0x0003
    line.long 0x000 "GPIODATA #128, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0204++0x0003
    line.long 0x000 "GPIODATA #129, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0208++0x0003
    line.long 0x000 "GPIODATA #130, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x020C++0x0003
    line.long 0x000 "GPIODATA #131, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0210++0x0003
    line.long 0x000 "GPIODATA #132, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0214++0x0003
    line.long 0x000 "GPIODATA #133, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0218++0x0003
    line.long 0x000 "GPIODATA #134, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x021C++0x0003
    line.long 0x000 "GPIODATA #135, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0220++0x0003
    line.long 0x000 "GPIODATA #136, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0224++0x0003
    line.long 0x000 "GPIODATA #137, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0228++0x0003
    line.long 0x000 "GPIODATA #138, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x022C++0x0003
    line.long 0x000 "GPIODATA #139, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0230++0x0003
    line.long 0x000 "GPIODATA #140, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0234++0x0003
    line.long 0x000 "GPIODATA #141, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0238++0x0003
    line.long 0x000 "GPIODATA #142, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x023C++0x0003
    line.long 0x000 "GPIODATA #143, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0240++0x0003
    line.long 0x000 "GPIODATA #144, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0244++0x0003
    line.long 0x000 "GPIODATA #145, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0248++0x0003
    line.long 0x000 "GPIODATA #146, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x024C++0x0003
    line.long 0x000 "GPIODATA #147, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0250++0x0003
    line.long 0x000 "GPIODATA #148, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0254++0x0003
    line.long 0x000 "GPIODATA #149, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0258++0x0003
    line.long 0x000 "GPIODATA #150, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x025C++0x0003
    line.long 0x000 "GPIODATA #151, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0260++0x0003
    line.long 0x000 "GPIODATA #152, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0264++0x0003
    line.long 0x000 "GPIODATA #153, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0268++0x0003
    line.long 0x000 "GPIODATA #154, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x026C++0x0003
    line.long 0x000 "GPIODATA #155, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0270++0x0003
    line.long 0x000 "GPIODATA #156, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0274++0x0003
    line.long 0x000 "GPIODATA #157, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0278++0x0003
    line.long 0x000 "GPIODATA #158, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x027C++0x0003
    line.long 0x000 "GPIODATA #159, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0280++0x0003
    line.long 0x000 "GPIODATA #160, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0284++0x0003
    line.long 0x000 "GPIODATA #161, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0288++0x0003
    line.long 0x000 "GPIODATA #162, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x028C++0x0003
    line.long 0x000 "GPIODATA #163, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0290++0x0003
    line.long 0x000 "GPIODATA #164, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0294++0x0003
    line.long 0x000 "GPIODATA #165, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0298++0x0003
    line.long 0x000 "GPIODATA #166, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x029C++0x0003
    line.long 0x000 "GPIODATA #167, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x02A0++0x0003
    line.long 0x000 "GPIODATA #168, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x02A4++0x0003
    line.long 0x000 "GPIODATA #169, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x02A8++0x0003
    line.long 0x000 "GPIODATA #170, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x02AC++0x0003
    line.long 0x000 "GPIODATA #171, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x02B0++0x0003
    line.long 0x000 "GPIODATA #172, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x02B4++0x0003
    line.long 0x000 "GPIODATA #173, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x02B8++0x0003
    line.long 0x000 "GPIODATA #174, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x02BC++0x0003
    line.long 0x000 "GPIODATA #175, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x02C0++0x0003
    line.long 0x000 "GPIODATA #176, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x02C4++0x0003
    line.long 0x000 "GPIODATA #177, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x02C8++0x0003
    line.long 0x000 "GPIODATA #178, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x02CC++0x0003
    line.long 0x000 "GPIODATA #179, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x02D0++0x0003
    line.long 0x000 "GPIODATA #180, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x02D4++0x0003
    line.long 0x000 "GPIODATA #181, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x02D8++0x0003
    line.long 0x000 "GPIODATA #182, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x02DC++0x0003
    line.long 0x000 "GPIODATA #183, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x02E0++0x0003
    line.long 0x000 "GPIODATA #184, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x02E4++0x0003
    line.long 0x000 "GPIODATA #185, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x02E8++0x0003
    line.long 0x000 "GPIODATA #186, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x02EC++0x0003
    line.long 0x000 "GPIODATA #187, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x02F0++0x0003
    line.long 0x000 "GPIODATA #188, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x02F4++0x0003
    line.long 0x000 "GPIODATA #189, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x02F8++0x0003
    line.long 0x000 "GPIODATA #190, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x02FC++0x0003
    line.long 0x000 "GPIODATA #191, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0300++0x0003
    line.long 0x000 "GPIODATA #192, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0304++0x0003
    line.long 0x000 "GPIODATA #193, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0308++0x0003
    line.long 0x000 "GPIODATA #194, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x030C++0x0003
    line.long 0x000 "GPIODATA #195, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0310++0x0003
    line.long 0x000 "GPIODATA #196, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0314++0x0003
    line.long 0x000 "GPIODATA #197, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0318++0x0003
    line.long 0x000 "GPIODATA #198, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x031C++0x0003
    line.long 0x000 "GPIODATA #199, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0320++0x0003
    line.long 0x000 "GPIODATA #200, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0324++0x0003
    line.long 0x000 "GPIODATA #201, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0328++0x0003
    line.long 0x000 "GPIODATA #202, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x032C++0x0003
    line.long 0x000 "GPIODATA #203, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0330++0x0003
    line.long 0x000 "GPIODATA #204, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0334++0x0003
    line.long 0x000 "GPIODATA #205, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0338++0x0003
    line.long 0x000 "GPIODATA #206, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x033C++0x0003
    line.long 0x000 "GPIODATA #207, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0340++0x0003
    line.long 0x000 "GPIODATA #208, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0344++0x0003
    line.long 0x000 "GPIODATA #209, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0348++0x0003
    line.long 0x000 "GPIODATA #210, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x034C++0x0003
    line.long 0x000 "GPIODATA #211, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0350++0x0003
    line.long 0x000 "GPIODATA #212, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0354++0x0003
    line.long 0x000 "GPIODATA #213, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0358++0x0003
    line.long 0x000 "GPIODATA #214, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x035C++0x0003
    line.long 0x000 "GPIODATA #215, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0360++0x0003
    line.long 0x000 "GPIODATA #216, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0364++0x0003
    line.long 0x000 "GPIODATA #217, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0368++0x0003
    line.long 0x000 "GPIODATA #218, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x036C++0x0003
    line.long 0x000 "GPIODATA #219, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0370++0x0003
    line.long 0x000 "GPIODATA #220, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0374++0x0003
    line.long 0x000 "GPIODATA #221, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0378++0x0003
    line.long 0x000 "GPIODATA #222, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x037C++0x0003
    line.long 0x000 "GPIODATA #223, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0380++0x0003
    line.long 0x000 "GPIODATA #224, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0384++0x0003
    line.long 0x000 "GPIODATA #225, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0388++0x0003
    line.long 0x000 "GPIODATA #226, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x038C++0x0003
    line.long 0x000 "GPIODATA #227, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0390++0x0003
    line.long 0x000 "GPIODATA #228, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0394++0x0003
    line.long 0x000 "GPIODATA #229, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x0398++0x0003
    line.long 0x000 "GPIODATA #230, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x039C++0x0003
    line.long 0x000 "GPIODATA #231, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x03A0++0x0003
    line.long 0x000 "GPIODATA #232, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x03A4++0x0003
    line.long 0x000 "GPIODATA #233, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x03A8++0x0003
    line.long 0x000 "GPIODATA #234, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x03AC++0x0003
    line.long 0x000 "GPIODATA #235, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x03B0++0x0003
    line.long 0x000 "GPIODATA #236, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x03B4++0x0003
    line.long 0x000 "GPIODATA #237, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x03B8++0x0003
    line.long 0x000 "GPIODATA #238, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x03BC++0x0003
    line.long 0x000 "GPIODATA #239, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x03C0++0x0003
    line.long 0x000 "GPIODATA #240, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x03C4++0x0003
    line.long 0x000 "GPIODATA #241, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x03C8++0x0003
    line.long 0x000 "GPIODATA #242, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x03CC++0x0003
    line.long 0x000 "GPIODATA #243, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x03D0++0x0003
    line.long 0x000 "GPIODATA #244, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x03D4++0x0003
    line.long 0x000 "GPIODATA #245, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x03D8++0x0003
    line.long 0x000 "GPIODATA #246, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x03DC++0x0003
    line.long 0x000 "GPIODATA #247, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x03E0++0x0003
    line.long 0x000 "GPIODATA #248, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x03E4++0x0003
    line.long 0x000 "GPIODATA #249, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x03E8++0x0003
    line.long 0x000 "GPIODATA #250, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x03EC++0x0003
    line.long 0x000 "GPIODATA #251, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x03F0++0x0003
    line.long 0x000 "GPIODATA #252, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x03F4++0x0003
    line.long 0x000 "GPIODATA #253, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x03F8++0x0003
    line.long 0x000 "GPIODATA #254, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

  group 0x03FC++0x0003
    line.long 0x000 "GPIODATA #255, Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Input / Output Data"

; ------------------------ GPIODIR member of gpio ------------------------

  group 0x0400++0x0003
    line.long 0x000 "GPIODIR, Data Direction Register"
    textline "                   "
    bitfld.long 0x0 0.--7. " DIR                       ,Data Direction Control" "S0 (0),S1 (1),%x..."

; ------------------------ GPIOIS member of gpio ------------------------

  group 0x0404++0x0003
    line.long 0x000 "GPIOIS, Interrupt Sense Register"
    textline "                   "
    bitfld.long 0x0 0.--7. " INTSENSE                  ,Interrupt Sense Control" "S0 (0),S1 (1),%x..."

; ------------------------ GPIOIBE member of gpio ------------------------

  group 0x0408++0x0003
    line.long 0x000 "GPIOIBE, Interrupt Both-Edges Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " INTEDGE                   ,Interrupt Both-Edges Control"

; ------------------------ GPIOIEV member of gpio ------------------------

  group 0x040C++0x0003
    line.long 0x000 "GPIOIEV, Interrupt Event Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " INTEVENT                  ,Interrupt Event Control"

; ------------------------ GPIOIE member of gpio ------------------------

  group 0x0410++0x0003
    line.long 0x000 "GPIOIE, Interrupt Mask Register"
    textline "                   "
    bitfld.long 0x0 0.--7. " INTENA                    ,Interrupt Mask Control" "S0 (0),S1 (1),%x..."

; ------------------------ GPIORIS member of gpio ------------------------

  rgroup 0x0414++0x0003
    line.long 0x000 "GPIORIS, Raw Interrupt Status Register"
    textline "                   "
    bitfld.long 0x0 0.--7. " INTRAW                    ,Raw Interrupt Status" "S0 (0),S1 (1),%x..."

; ------------------------ GPIOMIS member of gpio ------------------------

  rgroup 0x0418++0x0003
    line.long 0x000 "GPIOMIS, Masked Interrupt Status Register"
    textline "                   "
    bitfld.long 0x0 0.--7. " INTMASK                   ,Masked Interrupt Status" "S0 (0),S1 (1),%x..."

; ------------------------ GPIOIC member of gpio ------------------------

  group 0x041C++0x0003
    line.long 0x000 "GPIOIC, Interrupt Clear Register"
    textline "                   "
    bitfld.long 0x0 0.--7. " INTCLR                    ,Interrupt Clear Control" "S0 (0),S1 (1),%x..."

; ----------------------- GPIOAFSEL member of gpio -----------------------

  group 0x0420++0x0003
    line.long 0x000 "GPIOAFSEL, Mode Control Select Register"
    textline "                   "
    bitfld.long 0x0 0.--7. " MSEL                      ,Mode Control Select" "S0 (0),S1 (1),%x..."

; --------------------- GPIOPeriphID0 member of gpio ---------------------

  rgroup 0x0FE0++0x0003
    line.long 0x000 "GPIOPeriphID0, GPIO Identification Register 0"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " PartNumber0               ,Part Number 0"

; --------------------- GPIOPeriphID1 member of gpio ---------------------

  rgroup 0x0FE4++0x0003
    line.long 0x000 "GPIOPeriphID1, GPIO Identification Register 1"
    textline "                   "
    hexmask.long.byte 0x0 0.--3. 0x1 0x0 " PartNumber1               ,Part Number 1"
    textline "                   "
    hexmask.long.byte 0x0 4.--7. 0x1 0x0 " Designer0                 ,Designer Number 0"

; --------------------- GPIOPeriphID2 member of gpio ---------------------

  rgroup 0x0FE8++0x0003
    line.long 0x000 "GPIOPeriphID2, GPIO Identification Register 2"
    textline "                   "
    hexmask.long.byte 0x0 0.--3. 0x1 0x0 " Designer1                 ,Designer Number 1"
    textline "                   "
    hexmask.long.byte 0x0 4.--7. 0x1 0x0 " Revision                  ,Revision Number"

; --------------------- GPIOPeriphID3 member of gpio ---------------------

  rgroup 0x0FEC++0x0003
    line.long 0x000 "GPIOPeriphID3, GPIO Identification Register 3"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " Configuration             ,Configuration Number"

; --------------------- GPIOPCellID0 member of gpio ---------------------

  rgroup 0x0FF0++0x0003
    line.long 0x000 "GPIOPCellID0, PrimeCell Identification Register 0"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " GPIOPCellID0              ,Cell Identification Number 0"

; --------------------- GPIOPCellID1 member of gpio ---------------------

  rgroup 0x0FF4++0x0003
    line.long 0x000 "GPIOPCellID1, PrimeCell Identification Register 1"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " GPIOPCellID1              ,Cell Identification Number 1"

; --------------------- GPIOPCellID2 member of gpio ---------------------

  rgroup 0x0FF8++0x0003
    line.long 0x000 "GPIOPCellID2, PrimeCell Identification Register 2"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " GPIOPCellID2              ,Cell Identification Number 2"

; --------------------- GPIOPCellID3 member of gpio ---------------------

  rgroup 0x0FFC++0x0003
    line.long 0x000 "GPIOPCellID3, PrimeCell Identification Register 3"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " GPIOPCellID3              ,Cell Identification Number 3"

tree.end

; -------------------------------------------------------------------
; End Block - gpio
; -------------------------------------------------------------------
tree.end
; @file:      i2c.per
; Chip name:  SHASTA
; Module:     i2c
; 
; Generated by the pmm metagen library.
;
; ===================================================================
; Copyright (C) 2018 Infineon Technologies AG
; All rights reserved.
; ===================================================================
;
; ===================================================================
; This document contains proprietary information. Passing on and
; copying of this document, and communication of its contents is not
; permitted without prior written authorisation.
; ===================================================================

; This file is automatically generated. Do not edit!


config 32. 8.
width 20.

tree "Block - i2c"
; -------------------------------------------------------------------
; Begin Block - i2c
; -------------------------------------------------------------------
base D:0x700B0000

tree "i2c"
; -------------------------- ADDR member of i2c --------------------------

  group 0x0000++0x0003
    line.long 0x000 "ADDR, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " GCE                       ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--2. 0x1 0x0 " SLAX                      ,"
    textline "                   "
    hexmask.long.byte 0x0 3.--7. 0x1 0x0 " SLA                       ,"

; -------------------------- DATA member of i2c --------------------------

  group 0x0004++0x0003
    line.long 0x000 "DATA, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,contain the received byte"

; -------------------------- CNTR member of i2c --------------------------

  group 0x0008++0x0003
    line.long 0x000 "CNTR, "
    textline "                   "
    hexmask.long.byte 0x0 2.--2. 0x1 0x0 " AAK                       ,"
    textline "                   "
    hexmask.long.byte 0x0 3.--3. 0x1 0x0 " IFLG                      ,"
    textline "                   "
    hexmask.long.byte 0x0 4.--4. 0x1 0x0 " STP                       ,"
    textline "                   "
    hexmask.long.byte 0x0 5.--5. 0x1 0x0 " STA                       ,"
    textline "                   "
    hexmask.long.byte 0x0 6.--6. 0x1 0x0 " ENAB                      ,"
    textline "                   "
    hexmask.long.byte 0x0 7.--7. 0x1 0x0 " IEN                       ,"

; ------------------------ STAT_CCR member of i2c ------------------------

  group 0x000C++0x0003
    line.long 0x000 "STAT_CCR, "
    textline "                   "
    hexmask.long.byte 0x0 0.--2. 0x1 0x0 " N                         ,"
    textline "                   "
    hexmask.long.byte 0x0 3.--7. 0x1 0x0 " CODE                      ,"
    textline "                   "
    hexmask.long.byte 0x0 3.--6. 0x1 0x0 " M                         ,"

; ------------------------- XADDR member of i2c -------------------------

  group 0x0010++0x0003
    line.long 0x000 "XADDR, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " SLAX                      ,"

; -------------------------- SRST member of i2c --------------------------

  group 0x001C++0x0003
    line.long 0x000 "SRST, "
    textline "                   "
    hexmask.long.byte 0x0 0.--6. 0x1 0x0 " RST                       ,"

tree.end

; -------------------------------------------------------------------
; End Block - i2c
; -------------------------------------------------------------------
tree.end
; @file:      isen.per
; Chip name:  SHASTA
; Module:     isen
; 
; Generated by the pmm metagen library.
;
; ===================================================================
; Copyright (C) 2018 Infineon Technologies AG
; All rights reserved.
; ===================================================================
;
; ===================================================================
; This document contains proprietary information. Passing on and
; copying of this document, and communication of its contents is not
; permitted without prior written authorisation.
; ===================================================================

; This file is automatically generated. Do not edit!


config 32. 8.
width 20.

tree "Block - isen"
; -------------------------------------------------------------------
; Begin Block - isen
; -------------------------------------------------------------------
base D:0x70002400

tree "isen0"
; ------------------------ CE_CFG1 member of isen ------------------------

  group 0x0000++0x0003
    line.long 0x000 "CE_CFG1, Current sense tracking gain in the HiZ state.  The tracking gain defines the relative stength of the IS ADC based correction term applied to the emulated current waveform.  The HiZ state generally refers to the state when all primary and secondary switches are off.  Note that this register should be set to 0 for primary side current sense and for the boost topology."
    textline "                   "
    hexmask.long.byte 0x0 0.--3. 0x1 0x0 " ce_ktrack_hiz             ,Current sense tracking gain in the HiZ state.  The tracking gain defines the relative stength of the IS ADC based correction term applied to the emulated current waveform.  The HiZ state generally refers to the state when all primary and secondary switches are off.  Note that this register should be set to 0 for primary side current sense and for the boost topology."
    textline "                   "
    hexmask.long.byte 0x0 4.--7. 0x1 0x0 " ce_ktrack_off             ,Current sense tracking gain in the OFF state.  The tracking gain defines the relative stength of the IS ADC based correction term applied to the emulated current waveform.  The OFF state generally refers to the state when the output inductor current is in its downward slope cycle (e.g., primary FETs off, secondary FETs on in a bridge topology).  Note that this register should be set to 0 for primary side current sense and for the boost topology."
    textline "                   "
    hexmask.long.byte 0x0 8.--11. 0x1 0x0 " ce_ktrack_on              ,Current sense tracking gain in the ON state.  The tracking gain defines the relative stength of the IS ADC based correction term applied to the emulated current waveform.  The ON state generally refers to the state when the output inductor current is in its upward slope cycle (e.g., primary FETs on in a bridge topology)."
    textline "                   "
    hexmask.long.word 0x0 12.--22. 0x1 0x0 " ce_kslope_didv            ,Output inductor (Lout) current sense slope normalized to Code/Samples @ 1.0V. "
    textline "                   "
    hexmask.long.byte 0x0 23.--27. 0x1 0x0 " ce_pwmwin_dly             ,Defines delay used to align internal PWM signals to incoming current sense waveform. "
    textline "                   "
    hexmask.long.byte 0x0 28.--29. 0x1 0x0 " ce_pwmwin_tr_dly          ,This field currently not used."
    textline "                   "
    hexmask.long.byte 0x0 30.--30. 0x1 0x0 " ce_ladj_en                ,Inductor slope correction function enable.  When enabled, the controller will correct for errors in ce_kslope_didv based on the incoming current sense waveform. "
    textline "                   "
    hexmask.long.byte 0x0 31.--31. 0x1 0x0 " ce_ps_current_emu         ,Primary-side, secondary-side current sense select. "

; ------------------------ CE_CFG2 member of isen ------------------------

  group 0x0004++0x0003
    line.long 0x000 "CE_CFG2, Defines ON state for current estimator based on the equation, &emsp;ON = &( ~ce_on_mask0[11:0] | pwm[11:0] ) || &( ~ce_on_mask1[11:0] | pwm[11:0] ) where, [0] corresponds to PWM1, [11] corresponds to PWM12 "
    textline "                   "
    hexmask.long.word 0x0 0.--11. 0x1 0x0 " ce_on_mask0               ,Defines ON state for current estimator based on the equation, &emsp;ON = &( ~ce_on_mask0[11:0] | pwm[11:0] ) || &( ~ce_on_mask1[11:0] | pwm[11:0] ) where, [0] corresponds to PWM1, [11] corresponds to PWM12 "
    textline "                   "
    hexmask.long.word 0x0 12.--23. 0x1 0x0 " ce_on_mask1               ,Defines ON state for current estimator based on the equation, &emsp;ON = &( ~ce_on_mask0[11:0] | pwm[11:0] ) || &( ~ce_on_mask1[11:0] | pwm[11:0] ) where, [0] corresponds to PWM1, [11] corresponds to PWM12 "
    textline "                   "
    hexmask.long.byte 0x0 24.--29. 0x1 0x0 " ce_dt_l_slope             ,Defines the slope of the output inductance dependence on current.  Although actually inductor variation with current is non-linear this compensation introduces a linear correction to the inductor slope.  It is recommended to use the 0A inductance as one point.  The user can choose the second point for the best fit curve.  Computed as follows:  kslope_0 = 1V * 10ns / L(I_0), I_0 = 0A kslope_1 = 1V * 10ns / L(I_1), I_1 = user selected current  ce_dt_l_slope = round(2^15 * (kslope_1-kslope_0)/(I_1-I_0))  Example: I_0 = 0A, L(I_0) = 470nH ==> kslope_0 = 0.021276 I_1 = 50A, L(I_1) = 420nH ==> kslope_1 = 0.023809  ce_dt_l_slope = round(2^15*(0.023809-0.021276)/50) = 2"

; ------------------------ CE_CFG3 member of isen ------------------------

  group 0x0008++0x0003
    line.long 0x000 "CE_CFG3, Defines OFF state for current estimator as follows: &emsp;OFF = &( ~ce_off_mask0[11:0] | pwm[11:0] ) && &( ~ce_off_mask1[11:0] | pwm[11:0] ) && !ON where, [0] corresponds to PWM1, [11] corresponds to PWM12 "
    textline "                   "
    hexmask.long.word 0x0 0.--11. 0x1 0x0 " ce_off_mask0              ,Defines OFF state for current estimator as follows: &emsp;OFF = &( ~ce_off_mask0[11:0] | pwm[11:0] ) && &( ~ce_off_mask1[11:0] | pwm[11:0] ) && !ON where, [0] corresponds to PWM1, [11] corresponds to PWM12 "
    textline "                   "
    hexmask.long.word 0x0 12.--23. 0x1 0x0 " ce_off_mask1              ,Defines OFF state for current estimator as follows: &emsp;OFF = &( ~ce_off_mask0[11:0] | pwm[11:0] ) && &( ~ce_off_mask1[11:0] | pwm[11:0] ) && !ON where, [0] corresponds to PWM1, [11] corresponds to PWM12 "
    textline "                   "
    hexmask.long.byte 0x0 24.--28. 0x1 0x0 " ce_ltrace                 ,Defines parasitic trace inductance as seen by current sense input.  Computed as follows:  ce_ltrace = Ltrace / (Rtrace * dt)  where, Ltrace = parasitic trace inductance being compensated Rtrace = current sense trace resistance dt = 10ns  Example: Ltrace = 300pH, Rtrace = 0.5mOhm ce_ltrace = 300pH/(1.0mOhm*10ns) = 30"

; ---------------------- ISP_FAULT1 member of isen ----------------------

  group 0x000C++0x0003
    line.long 0x000 "ISP_FAULT1, Short ciruit protection (SCP) fault threshold.  The SCP threshold should be set highest among the various current protection thresholds as it requires only a single sample above the threshold to trip. The SCP threshold is applied per phase on multi-phase topologies.  Set this threshold to 0 to disable the fault detection."
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " isp_scp_thresh            ,Short ciruit protection (SCP) fault threshold.  The SCP threshold should be set highest among the various current protection thresholds as it requires only a single sample above the threshold to trip. The SCP threshold is applied per phase on multi-phase topologies.  Set this threshold to 0 to disable the fault detection."
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " isp_ncl_thresh            ,Inductor negative current limit (NCL) fault threshold. The NCL threshold is compared agains the instantaneous phase current.  When the phase current drops below the NCL thrshold the response is to turn off the FETs associated with the OFF state defined in ce_off_mask0,1.  In isolated topologies this corresponds to the SR FETs.  In general, turning off the SR FETs with a large negative inductor current does not produce a desirable result.  Set to the max positive setting, 127, to disable this fault protection and its response."
    textline "                   "
    hexmask.long.byte 0x0 16.--23. 0x1 0x0 " isp_track_thresh          ,is track fault threshold - TBD format and default values need to be updated  for simplicity  - currently set to S6.2 and will be updated once this fault is further defined"
    textline "                   "
    hexmask.long.byte 0x0 24.--26. 0x1 0x0 " ce_blank_ne_dly           ,Defines time after a PWM pulse falling edge during which the current sense is in emulation mode only (i.e., the tracking feedback from the current sense ADC is ignored)."
    textline "                   "
    hexmask.long.byte 0x0 27.--29. 0x1 0x0 " ce_blank_pe_dly           ,Defines time after a PWM pulse rising edge during which the current sense is in emulation mode only (i.e., the tracking feedback from the current sense ADC is ignored)."

; ------------------------ CE_CFG4 member of isen ------------------------

  group 0x0010++0x0003
    line.long 0x000 "CE_CFG4, Transformer magnetizing inductance (Lm) current sense slope normalized to Code/Samples @ 1.0V.  Only used for primary side current sense. "
    textline "                   "
    hexmask.long.word 0x0 0.--8. 0x1 0x0 " ce_kslope_lm              ,Transformer magnetizing inductance (Lm) current sense slope normalized to Code/Samples @ 1.0V.  Only used for primary side current sense. "
    textline "                   "
    hexmask.long.byte 0x0 9.--12. 0x1 0x0 " ce_iterm                  ,Current sense tracking error integrator coefficient.  Set to 0 to disable error accumulation."
    textline "                   "
    hexmask.long.byte 0x0 13.--14. 0x1 0x0 " ce_vout_sel               ,Current sense Vout source select.  Note that CDR in the table below indicates Current DoubleR topology on the secondary. "
    textline "                   "
    hexmask.long.byte 0x0 15.--17. 0x1 0x0 " ce_vrect_sel              ,Current sense Vrect source select. "
    textline "                   "
    hexmask.long.word 0x0 18.--26. 0x1 0x0 " ce_current_limit          ,Inductor peak current limit (PCL) fault threshold in ADC codes. The PWM pulse will be truncated beyond this limit.  Set to 0 to disable PCL fault protection. "
    textline "                   "
    hexmask.long.byte 0x0 27.--28. 0x1 0x0 " ce_topology               ,Current emulator topology select.  Defines the inductor voltage equations for Von, Voff. "
    textline "                   "
    hexmask.long.byte 0x0 29.--29. 0x1 0x0 " isp_fsw_sync_sel          ,Defines which loop's frequency is used for averaging current over switching cycle. "

; ------------------------ ISP_APC member of isen ------------------------

  group 0x0014++0x0003
    line.long 0x000 "ISP_APC, Current Sense ADC Amps per Code (APC), maps the current sense ADC LSB into Amps. Computed from PMBus command as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--10. 0x1 0x0 " isp_apc                   ,Current Sense ADC Amps per Code (APC), maps the current sense ADC LSB into Amps. Computed from PMBus command as follows: "
    textline "                   "
    hexmask.long.byte 0x0 11.--18. 0x1 0x0 " isp_ioffset               ,Phase current offset Computed from PMBus command as follows: "

tree.end
base D:0x70002800

tree "isen1"
; ------------------------ CE_CFG1 member of isen ------------------------

  group 0x0000++0x0003
    line.long 0x000 "CE_CFG1, Current sense tracking gain in the HiZ state.  The tracking gain defines the relative stength of the IS ADC based correction term applied to the emulated current waveform.  The HiZ state generally refers to the state when all primary and secondary switches are off.  Note that this register should be set to 0 for primary side current sense and for the boost topology."
    textline "                   "
    hexmask.long.byte 0x0 0.--3. 0x1 0x0 " ce_ktrack_hiz             ,Current sense tracking gain in the HiZ state.  The tracking gain defines the relative stength of the IS ADC based correction term applied to the emulated current waveform.  The HiZ state generally refers to the state when all primary and secondary switches are off.  Note that this register should be set to 0 for primary side current sense and for the boost topology."
    textline "                   "
    hexmask.long.byte 0x0 4.--7. 0x1 0x0 " ce_ktrack_off             ,Current sense tracking gain in the OFF state.  The tracking gain defines the relative stength of the IS ADC based correction term applied to the emulated current waveform.  The OFF state generally refers to the state when the output inductor current is in its downward slope cycle (e.g., primary FETs off, secondary FETs on in a bridge topology).  Note that this register should be set to 0 for primary side current sense and for the boost topology."
    textline "                   "
    hexmask.long.byte 0x0 8.--11. 0x1 0x0 " ce_ktrack_on              ,Current sense tracking gain in the ON state.  The tracking gain defines the relative stength of the IS ADC based correction term applied to the emulated current waveform.  The ON state generally refers to the state when the output inductor current is in its upward slope cycle (e.g., primary FETs on in a bridge topology)."
    textline "                   "
    hexmask.long.word 0x0 12.--22. 0x1 0x0 " ce_kslope_didv            ,Output inductor (Lout) current sense slope normalized to Code/Samples @ 1.0V. "
    textline "                   "
    hexmask.long.byte 0x0 23.--27. 0x1 0x0 " ce_pwmwin_dly             ,Defines delay used to align internal PWM signals to incoming current sense waveform. "
    textline "                   "
    hexmask.long.byte 0x0 28.--29. 0x1 0x0 " ce_pwmwin_tr_dly          ,This field currently not used."
    textline "                   "
    hexmask.long.byte 0x0 30.--30. 0x1 0x0 " ce_ladj_en                ,Inductor slope correction function enable.  When enabled, the controller will correct for errors in ce_kslope_didv based on the incoming current sense waveform. "
    textline "                   "
    hexmask.long.byte 0x0 31.--31. 0x1 0x0 " ce_ps_current_emu         ,Primary-side, secondary-side current sense select. "

; ------------------------ CE_CFG2 member of isen ------------------------

  group 0x0004++0x0003
    line.long 0x000 "CE_CFG2, Defines ON state for current estimator based on the equation, &emsp;ON = &( ~ce_on_mask0[11:0] | pwm[11:0] ) || &( ~ce_on_mask1[11:0] | pwm[11:0] ) where, [0] corresponds to PWM1, [11] corresponds to PWM12 "
    textline "                   "
    hexmask.long.word 0x0 0.--11. 0x1 0x0 " ce_on_mask0               ,Defines ON state for current estimator based on the equation, &emsp;ON = &( ~ce_on_mask0[11:0] | pwm[11:0] ) || &( ~ce_on_mask1[11:0] | pwm[11:0] ) where, [0] corresponds to PWM1, [11] corresponds to PWM12 "
    textline "                   "
    hexmask.long.word 0x0 12.--23. 0x1 0x0 " ce_on_mask1               ,Defines ON state for current estimator based on the equation, &emsp;ON = &( ~ce_on_mask0[11:0] | pwm[11:0] ) || &( ~ce_on_mask1[11:0] | pwm[11:0] ) where, [0] corresponds to PWM1, [11] corresponds to PWM12 "
    textline "                   "
    hexmask.long.byte 0x0 24.--29. 0x1 0x0 " ce_dt_l_slope             ,Defines the slope of the output inductance dependence on current.  Although actually inductor variation with current is non-linear this compensation introduces a linear correction to the inductor slope.  It is recommended to use the 0A inductance as one point.  The user can choose the second point for the best fit curve.  Computed as follows:  kslope_0 = 1V * 10ns / L(I_0), I_0 = 0A kslope_1 = 1V * 10ns / L(I_1), I_1 = user selected current  ce_dt_l_slope = round(2^15 * (kslope_1-kslope_0)/(I_1-I_0))  Example: I_0 = 0A, L(I_0) = 470nH ==> kslope_0 = 0.021276 I_1 = 50A, L(I_1) = 420nH ==> kslope_1 = 0.023809  ce_dt_l_slope = round(2^15*(0.023809-0.021276)/50) = 2"

; ------------------------ CE_CFG3 member of isen ------------------------

  group 0x0008++0x0003
    line.long 0x000 "CE_CFG3, Defines OFF state for current estimator as follows: &emsp;OFF = &( ~ce_off_mask0[11:0] | pwm[11:0] ) && &( ~ce_off_mask1[11:0] | pwm[11:0] ) && !ON where, [0] corresponds to PWM1, [11] corresponds to PWM12 "
    textline "                   "
    hexmask.long.word 0x0 0.--11. 0x1 0x0 " ce_off_mask0              ,Defines OFF state for current estimator as follows: &emsp;OFF = &( ~ce_off_mask0[11:0] | pwm[11:0] ) && &( ~ce_off_mask1[11:0] | pwm[11:0] ) && !ON where, [0] corresponds to PWM1, [11] corresponds to PWM12 "
    textline "                   "
    hexmask.long.word 0x0 12.--23. 0x1 0x0 " ce_off_mask1              ,Defines OFF state for current estimator as follows: &emsp;OFF = &( ~ce_off_mask0[11:0] | pwm[11:0] ) && &( ~ce_off_mask1[11:0] | pwm[11:0] ) && !ON where, [0] corresponds to PWM1, [11] corresponds to PWM12 "
    textline "                   "
    hexmask.long.byte 0x0 24.--28. 0x1 0x0 " ce_ltrace                 ,Defines parasitic trace inductance as seen by current sense input.  Computed as follows:  ce_ltrace = Ltrace / (Rtrace * dt)  where, Ltrace = parasitic trace inductance being compensated Rtrace = current sense trace resistance dt = 10ns  Example: Ltrace = 300pH, Rtrace = 0.5mOhm ce_ltrace = 300pH/(1.0mOhm*10ns) = 30"

; ---------------------- ISP_FAULT1 member of isen ----------------------

  group 0x000C++0x0003
    line.long 0x000 "ISP_FAULT1, Short ciruit protection (SCP) fault threshold.  The SCP threshold should be set highest among the various current protection thresholds as it requires only a single sample above the threshold to trip. The SCP threshold is applied per phase on multi-phase topologies.  Set this threshold to 0 to disable the fault detection."
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " isp_scp_thresh            ,Short ciruit protection (SCP) fault threshold.  The SCP threshold should be set highest among the various current protection thresholds as it requires only a single sample above the threshold to trip. The SCP threshold is applied per phase on multi-phase topologies.  Set this threshold to 0 to disable the fault detection."
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " isp_ncl_thresh            ,Inductor negative current limit (NCL) fault threshold. The NCL threshold is compared agains the instantaneous phase current.  When the phase current drops below the NCL thrshold the response is to turn off the FETs associated with the OFF state defined in ce_off_mask0,1.  In isolated topologies this corresponds to the SR FETs.  In general, turning off the SR FETs with a large negative inductor current does not produce a desirable result.  Set to the max positive setting, 127, to disable this fault protection and its response."
    textline "                   "
    hexmask.long.byte 0x0 16.--23. 0x1 0x0 " isp_track_thresh          ,is track fault threshold - TBD format and default values need to be updated  for simplicity  - currently set to S6.2 and will be updated once this fault is further defined"
    textline "                   "
    hexmask.long.byte 0x0 24.--26. 0x1 0x0 " ce_blank_ne_dly           ,Defines time after a PWM pulse falling edge during which the current sense is in emulation mode only (i.e., the tracking feedback from the current sense ADC is ignored)."
    textline "                   "
    hexmask.long.byte 0x0 27.--29. 0x1 0x0 " ce_blank_pe_dly           ,Defines time after a PWM pulse rising edge during which the current sense is in emulation mode only (i.e., the tracking feedback from the current sense ADC is ignored)."

; ------------------------ CE_CFG4 member of isen ------------------------

  group 0x0010++0x0003
    line.long 0x000 "CE_CFG4, Transformer magnetizing inductance (Lm) current sense slope normalized to Code/Samples @ 1.0V.  Only used for primary side current sense. "
    textline "                   "
    hexmask.long.word 0x0 0.--8. 0x1 0x0 " ce_kslope_lm              ,Transformer magnetizing inductance (Lm) current sense slope normalized to Code/Samples @ 1.0V.  Only used for primary side current sense. "
    textline "                   "
    hexmask.long.byte 0x0 9.--12. 0x1 0x0 " ce_iterm                  ,Current sense tracking error integrator coefficient.  Set to 0 to disable error accumulation."
    textline "                   "
    hexmask.long.byte 0x0 13.--14. 0x1 0x0 " ce_vout_sel               ,Current sense Vout source select.  Note that CDR in the table below indicates Current DoubleR topology on the secondary. "
    textline "                   "
    hexmask.long.byte 0x0 15.--17. 0x1 0x0 " ce_vrect_sel              ,Current sense Vrect source select. "
    textline "                   "
    hexmask.long.word 0x0 18.--26. 0x1 0x0 " ce_current_limit          ,Inductor peak current limit (PCL) fault threshold in ADC codes. The PWM pulse will be truncated beyond this limit.  Set to 0 to disable PCL fault protection. "
    textline "                   "
    hexmask.long.byte 0x0 27.--28. 0x1 0x0 " ce_topology               ,Current emulator topology select.  Defines the inductor voltage equations for Von, Voff. "
    textline "                   "
    hexmask.long.byte 0x0 29.--29. 0x1 0x0 " isp_fsw_sync_sel          ,Defines which loop's frequency is used for averaging current over switching cycle. "

; ------------------------ ISP_APC member of isen ------------------------

  group 0x0014++0x0003
    line.long 0x000 "ISP_APC, Current Sense ADC Amps per Code (APC), maps the current sense ADC LSB into Amps. Computed from PMBus command as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--10. 0x1 0x0 " isp_apc                   ,Current Sense ADC Amps per Code (APC), maps the current sense ADC LSB into Amps. Computed from PMBus command as follows: "
    textline "                   "
    hexmask.long.byte 0x0 11.--18. 0x1 0x0 " isp_ioffset               ,Phase current offset Computed from PMBus command as follows: "

tree.end

; -------------------------------------------------------------------
; End Block - isen
; -------------------------------------------------------------------
tree.end
; @file:      mmu.per
; Chip name:  SHASTA
; Module:     mmu
; 
; Generated by the pmm metagen library.
;
; ===================================================================
; Copyright (C) 2018 Infineon Technologies AG
; All rights reserved.
; ===================================================================
;
; ===================================================================
; This document contains proprietary information. Passing on and
; copying of this document, and communication of its contents is not
; permitted without prior written authorisation.
; ===================================================================

; This file is automatically generated. Do not edit!


config 32. 8.
width 20.

tree "Block - mmu"
; -------------------------------------------------------------------
; Begin Block - mmu
; -------------------------------------------------------------------
base D:0x40004000

tree "mmu"
; ---------------------- MMU_LUT_ROM member of mmu ----------------------

  group 0x0000++0x0003
    line.long 0x000 "MMU_LUT_ROM #0, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0004++0x0003
    line.long 0x000 "MMU_LUT_ROM #1, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0008++0x0003
    line.long 0x000 "MMU_LUT_ROM #2, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x000C++0x0003
    line.long 0x000 "MMU_LUT_ROM #3, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0010++0x0003
    line.long 0x000 "MMU_LUT_ROM #4, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0014++0x0003
    line.long 0x000 "MMU_LUT_ROM #5, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0018++0x0003
    line.long 0x000 "MMU_LUT_ROM #6, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x001C++0x0003
    line.long 0x000 "MMU_LUT_ROM #7, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0020++0x0003
    line.long 0x000 "MMU_LUT_ROM #8, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0024++0x0003
    line.long 0x000 "MMU_LUT_ROM #9, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0028++0x0003
    line.long 0x000 "MMU_LUT_ROM #10, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x002C++0x0003
    line.long 0x000 "MMU_LUT_ROM #11, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0030++0x0003
    line.long 0x000 "MMU_LUT_ROM #12, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0034++0x0003
    line.long 0x000 "MMU_LUT_ROM #13, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0038++0x0003
    line.long 0x000 "MMU_LUT_ROM #14, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x003C++0x0003
    line.long 0x000 "MMU_LUT_ROM #15, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0040++0x0003
    line.long 0x000 "MMU_LUT_ROM #16, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0044++0x0003
    line.long 0x000 "MMU_LUT_ROM #17, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0048++0x0003
    line.long 0x000 "MMU_LUT_ROM #18, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x004C++0x0003
    line.long 0x000 "MMU_LUT_ROM #19, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0050++0x0003
    line.long 0x000 "MMU_LUT_ROM #20, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0054++0x0003
    line.long 0x000 "MMU_LUT_ROM #21, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0058++0x0003
    line.long 0x000 "MMU_LUT_ROM #22, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x005C++0x0003
    line.long 0x000 "MMU_LUT_ROM #23, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0060++0x0003
    line.long 0x000 "MMU_LUT_ROM #24, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0064++0x0003
    line.long 0x000 "MMU_LUT_ROM #25, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0068++0x0003
    line.long 0x000 "MMU_LUT_ROM #26, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x006C++0x0003
    line.long 0x000 "MMU_LUT_ROM #27, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0070++0x0003
    line.long 0x000 "MMU_LUT_ROM #28, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0074++0x0003
    line.long 0x000 "MMU_LUT_ROM #29, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0078++0x0003
    line.long 0x000 "MMU_LUT_ROM #30, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x007C++0x0003
    line.long 0x000 "MMU_LUT_ROM #31, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0080++0x0003
    line.long 0x000 "MMU_LUT_ROM #32, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0084++0x0003
    line.long 0x000 "MMU_LUT_ROM #33, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0088++0x0003
    line.long 0x000 "MMU_LUT_ROM #34, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x008C++0x0003
    line.long 0x000 "MMU_LUT_ROM #35, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0090++0x0003
    line.long 0x000 "MMU_LUT_ROM #36, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0094++0x0003
    line.long 0x000 "MMU_LUT_ROM #37, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0098++0x0003
    line.long 0x000 "MMU_LUT_ROM #38, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x009C++0x0003
    line.long 0x000 "MMU_LUT_ROM #39, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x00A0++0x0003
    line.long 0x000 "MMU_LUT_ROM #40, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x00A4++0x0003
    line.long 0x000 "MMU_LUT_ROM #41, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x00A8++0x0003
    line.long 0x000 "MMU_LUT_ROM #42, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x00AC++0x0003
    line.long 0x000 "MMU_LUT_ROM #43, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x00B0++0x0003
    line.long 0x000 "MMU_LUT_ROM #44, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x00B4++0x0003
    line.long 0x000 "MMU_LUT_ROM #45, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x00B8++0x0003
    line.long 0x000 "MMU_LUT_ROM #46, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x00BC++0x0003
    line.long 0x000 "MMU_LUT_ROM #47, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x00C0++0x0003
    line.long 0x000 "MMU_LUT_ROM #48, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x00C4++0x0003
    line.long 0x000 "MMU_LUT_ROM #49, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x00C8++0x0003
    line.long 0x000 "MMU_LUT_ROM #50, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x00CC++0x0003
    line.long 0x000 "MMU_LUT_ROM #51, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x00D0++0x0003
    line.long 0x000 "MMU_LUT_ROM #52, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x00D4++0x0003
    line.long 0x000 "MMU_LUT_ROM #53, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x00D8++0x0003
    line.long 0x000 "MMU_LUT_ROM #54, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x00DC++0x0003
    line.long 0x000 "MMU_LUT_ROM #55, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x00E0++0x0003
    line.long 0x000 "MMU_LUT_ROM #56, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x00E4++0x0003
    line.long 0x000 "MMU_LUT_ROM #57, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x00E8++0x0003
    line.long 0x000 "MMU_LUT_ROM #58, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x00EC++0x0003
    line.long 0x000 "MMU_LUT_ROM #59, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x00F0++0x0003
    line.long 0x000 "MMU_LUT_ROM #60, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x00F4++0x0003
    line.long 0x000 "MMU_LUT_ROM #61, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x00F8++0x0003
    line.long 0x000 "MMU_LUT_ROM #62, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x00FC++0x0003
    line.long 0x000 "MMU_LUT_ROM #63, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0100++0x0003
    line.long 0x000 "MMU_LUT_ROM #64, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0104++0x0003
    line.long 0x000 "MMU_LUT_ROM #65, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0108++0x0003
    line.long 0x000 "MMU_LUT_ROM #66, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x010C++0x0003
    line.long 0x000 "MMU_LUT_ROM #67, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0110++0x0003
    line.long 0x000 "MMU_LUT_ROM #68, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0114++0x0003
    line.long 0x000 "MMU_LUT_ROM #69, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0118++0x0003
    line.long 0x000 "MMU_LUT_ROM #70, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x011C++0x0003
    line.long 0x000 "MMU_LUT_ROM #71, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0120++0x0003
    line.long 0x000 "MMU_LUT_ROM #72, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0124++0x0003
    line.long 0x000 "MMU_LUT_ROM #73, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0128++0x0003
    line.long 0x000 "MMU_LUT_ROM #74, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x012C++0x0003
    line.long 0x000 "MMU_LUT_ROM #75, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0130++0x0003
    line.long 0x000 "MMU_LUT_ROM #76, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0134++0x0003
    line.long 0x000 "MMU_LUT_ROM #77, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0138++0x0003
    line.long 0x000 "MMU_LUT_ROM #78, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x013C++0x0003
    line.long 0x000 "MMU_LUT_ROM #79, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

; ---------------------- MMU_LUT_OTP member of mmu ----------------------

  group 0x0200++0x0003
    line.long 0x000 "MMU_LUT_OTP #0, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0204++0x0003
    line.long 0x000 "MMU_LUT_OTP #1, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0208++0x0003
    line.long 0x000 "MMU_LUT_OTP #2, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x020C++0x0003
    line.long 0x000 "MMU_LUT_OTP #3, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0210++0x0003
    line.long 0x000 "MMU_LUT_OTP #4, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0214++0x0003
    line.long 0x000 "MMU_LUT_OTP #5, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0218++0x0003
    line.long 0x000 "MMU_LUT_OTP #6, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x021C++0x0003
    line.long 0x000 "MMU_LUT_OTP #7, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0220++0x0003
    line.long 0x000 "MMU_LUT_OTP #8, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0224++0x0003
    line.long 0x000 "MMU_LUT_OTP #9, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0228++0x0003
    line.long 0x000 "MMU_LUT_OTP #10, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x022C++0x0003
    line.long 0x000 "MMU_LUT_OTP #11, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0230++0x0003
    line.long 0x000 "MMU_LUT_OTP #12, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0234++0x0003
    line.long 0x000 "MMU_LUT_OTP #13, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0238++0x0003
    line.long 0x000 "MMU_LUT_OTP #14, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x023C++0x0003
    line.long 0x000 "MMU_LUT_OTP #15, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0240++0x0003
    line.long 0x000 "MMU_LUT_OTP #16, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0244++0x0003
    line.long 0x000 "MMU_LUT_OTP #17, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0248++0x0003
    line.long 0x000 "MMU_LUT_OTP #18, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x024C++0x0003
    line.long 0x000 "MMU_LUT_OTP #19, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0250++0x0003
    line.long 0x000 "MMU_LUT_OTP #20, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0254++0x0003
    line.long 0x000 "MMU_LUT_OTP #21, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0258++0x0003
    line.long 0x000 "MMU_LUT_OTP #22, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x025C++0x0003
    line.long 0x000 "MMU_LUT_OTP #23, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0260++0x0003
    line.long 0x000 "MMU_LUT_OTP #24, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0264++0x0003
    line.long 0x000 "MMU_LUT_OTP #25, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0268++0x0003
    line.long 0x000 "MMU_LUT_OTP #26, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x026C++0x0003
    line.long 0x000 "MMU_LUT_OTP #27, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0270++0x0003
    line.long 0x000 "MMU_LUT_OTP #28, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0274++0x0003
    line.long 0x000 "MMU_LUT_OTP #29, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0278++0x0003
    line.long 0x000 "MMU_LUT_OTP #30, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x027C++0x0003
    line.long 0x000 "MMU_LUT_OTP #31, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0280++0x0003
    line.long 0x000 "MMU_LUT_OTP #32, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0284++0x0003
    line.long 0x000 "MMU_LUT_OTP #33, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0288++0x0003
    line.long 0x000 "MMU_LUT_OTP #34, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x028C++0x0003
    line.long 0x000 "MMU_LUT_OTP #35, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0290++0x0003
    line.long 0x000 "MMU_LUT_OTP #36, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0294++0x0003
    line.long 0x000 "MMU_LUT_OTP #37, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0298++0x0003
    line.long 0x000 "MMU_LUT_OTP #38, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x029C++0x0003
    line.long 0x000 "MMU_LUT_OTP #39, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x02A0++0x0003
    line.long 0x000 "MMU_LUT_OTP #40, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x02A4++0x0003
    line.long 0x000 "MMU_LUT_OTP #41, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x02A8++0x0003
    line.long 0x000 "MMU_LUT_OTP #42, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x02AC++0x0003
    line.long 0x000 "MMU_LUT_OTP #43, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x02B0++0x0003
    line.long 0x000 "MMU_LUT_OTP #44, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x02B4++0x0003
    line.long 0x000 "MMU_LUT_OTP #45, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x02B8++0x0003
    line.long 0x000 "MMU_LUT_OTP #46, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x02BC++0x0003
    line.long 0x000 "MMU_LUT_OTP #47, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x02C0++0x0003
    line.long 0x000 "MMU_LUT_OTP #48, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x02C4++0x0003
    line.long 0x000 "MMU_LUT_OTP #49, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x02C8++0x0003
    line.long 0x000 "MMU_LUT_OTP #50, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x02CC++0x0003
    line.long 0x000 "MMU_LUT_OTP #51, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x02D0++0x0003
    line.long 0x000 "MMU_LUT_OTP #52, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x02D4++0x0003
    line.long 0x000 "MMU_LUT_OTP #53, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x02D8++0x0003
    line.long 0x000 "MMU_LUT_OTP #54, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x02DC++0x0003
    line.long 0x000 "MMU_LUT_OTP #55, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x02E0++0x0003
    line.long 0x000 "MMU_LUT_OTP #56, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x02E4++0x0003
    line.long 0x000 "MMU_LUT_OTP #57, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x02E8++0x0003
    line.long 0x000 "MMU_LUT_OTP #58, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x02EC++0x0003
    line.long 0x000 "MMU_LUT_OTP #59, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x02F0++0x0003
    line.long 0x000 "MMU_LUT_OTP #60, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x02F4++0x0003
    line.long 0x000 "MMU_LUT_OTP #61, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x02F8++0x0003
    line.long 0x000 "MMU_LUT_OTP #62, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x02FC++0x0003
    line.long 0x000 "MMU_LUT_OTP #63, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

; ---------------------- MMU_LUT_RAM1 member of mmu ----------------------

  group 0x0400++0x0003
    line.long 0x000 "MMU_LUT_RAM1 #0, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0404++0x0003
    line.long 0x000 "MMU_LUT_RAM1 #1, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0408++0x0003
    line.long 0x000 "MMU_LUT_RAM1 #2, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x040C++0x0003
    line.long 0x000 "MMU_LUT_RAM1 #3, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0410++0x0003
    line.long 0x000 "MMU_LUT_RAM1 #4, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0414++0x0003
    line.long 0x000 "MMU_LUT_RAM1 #5, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0418++0x0003
    line.long 0x000 "MMU_LUT_RAM1 #6, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x041C++0x0003
    line.long 0x000 "MMU_LUT_RAM1 #7, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0420++0x0003
    line.long 0x000 "MMU_LUT_RAM1 #8, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0424++0x0003
    line.long 0x000 "MMU_LUT_RAM1 #9, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0428++0x0003
    line.long 0x000 "MMU_LUT_RAM1 #10, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x042C++0x0003
    line.long 0x000 "MMU_LUT_RAM1 #11, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0430++0x0003
    line.long 0x000 "MMU_LUT_RAM1 #12, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0434++0x0003
    line.long 0x000 "MMU_LUT_RAM1 #13, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0438++0x0003
    line.long 0x000 "MMU_LUT_RAM1 #14, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x043C++0x0003
    line.long 0x000 "MMU_LUT_RAM1 #15, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

; ---------------------- MMU_LUT_RAM2 member of mmu ----------------------

  group 0x0500++0x0003
    line.long 0x000 "MMU_LUT_RAM2 #0, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0504++0x0003
    line.long 0x000 "MMU_LUT_RAM2 #1, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0508++0x0003
    line.long 0x000 "MMU_LUT_RAM2 #2, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x050C++0x0003
    line.long 0x000 "MMU_LUT_RAM2 #3, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0510++0x0003
    line.long 0x000 "MMU_LUT_RAM2 #4, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0514++0x0003
    line.long 0x000 "MMU_LUT_RAM2 #5, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0518++0x0003
    line.long 0x000 "MMU_LUT_RAM2 #6, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x051C++0x0003
    line.long 0x000 "MMU_LUT_RAM2 #7, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0520++0x0003
    line.long 0x000 "MMU_LUT_RAM2 #8, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0524++0x0003
    line.long 0x000 "MMU_LUT_RAM2 #9, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0528++0x0003
    line.long 0x000 "MMU_LUT_RAM2 #10, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x052C++0x0003
    line.long 0x000 "MMU_LUT_RAM2 #11, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0530++0x0003
    line.long 0x000 "MMU_LUT_RAM2 #12, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0534++0x0003
    line.long 0x000 "MMU_LUT_RAM2 #13, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x0538++0x0003
    line.long 0x000 "MMU_LUT_RAM2 #14, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

  group 0x053C++0x0003
    line.long 0x000 "MMU_LUT_RAM2 #15, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PROT                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BASE_ADR                  ,"

; --------------------- MMU_PER_SPACE member of mmu ---------------------

  group 0x0600++0x0003
    line.long 0x000 "MMU_PER_SPACE, "
    textline "                   "
    hexmask.long 0x0 0.--27. " PER                       ,"

; ------------------- MMU_PER_SPACE_SET member of mmu -------------------

  group 0x0604++0x0003
    line.long 0x000 "MMU_PER_SPACE_SET, "
    textline "                   "
    hexmask.long 0x0 0.--27. " PER                       ,"

; ------------------- MMU_PER_SPACE_CLR member of mmu -------------------

  group 0x0608++0x0003
    line.long 0x000 "MMU_PER_SPACE_CLR, "
    textline "                   "
    hexmask.long 0x0 0.--27. " PER                       ,"

; ------------------------ MMU_CNFG member of mmu ------------------------

  group 0x0700++0x0003
    line.long 0x000 "MMU_CNFG, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " EN_MMU                    ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " EN_LOAD_MMU_TABLE         ,"

; ---------------------- MMU_ERR_RPT member of mmu ----------------------

  rgroup 0x0704++0x0003
    line.long 0x000 "MMU_ERR_RPT, "
    textline "                   "
    hexmask.long.byte 0x0 0.--6. 0x1 0x0 " BLK_ADR                   ,"
    textline "                   "
    hexmask.long.word 0x0 7.--21. 0x1 0x0 " BASE_ADR                  ,"
    textline "                   "
    hexmask.long.byte 0x0 22.--22. 0x1 0x0 " PROT                      ,"

; -------------------- MMU_ERR_RPT_CLR member of mmu --------------------

  group 0x0708++0x0003
    line.long 0x000 "MMU_ERR_RPT_CLR, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " CLR                       ,"

tree.end

; -------------------------------------------------------------------
; End Block - mmu
; -------------------------------------------------------------------
tree.end
; @file:      otp_sh.per
; Chip name:  SHASTA
; Module:     otp_sh
; 
; Generated by the pmm metagen library.
;
; ===================================================================
; Copyright (C) 2018 Infineon Technologies AG
; All rights reserved.
; ===================================================================
;
; ===================================================================
; This document contains proprietary information. Passing on and
; copying of this document, and communication of its contents is not
; permitted without prior written authorisation.
; ===================================================================

; This file is automatically generated. Do not edit!


config 32. 8.
width 20.

tree "Block - otp_sh"
; -------------------------------------------------------------------
; Begin Block - otp_sh
; -------------------------------------------------------------------
base D:0x50020000

tree "otp_sh_1"
; ------------------------ STAT member of otp_sh ------------------------

  rgroup 0x0000++0x0003
    line.long 0x000 "STAT, OTP Status regsiter"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PWR_STAT                  ,"
    textline "                   "
    hexmask.long.byte 0x0 4.--4. 0x1 0x0 " BUSY                      ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--8. 0x1 0x0 " CMP_STAT                  ,"
    textline "                   "
    hexmask.long.byte 0x0 9.--9. 0x1 0x0 " PRECH_STAT                ,"
    textline "                   "
    hexmask.long.byte 0x0 16.--16. 0x1 0x0 " RD1_FL                    ,"
    textline "                   "
    hexmask.long.byte 0x0 17.--17. 0x1 0x0 " RD2_FL                    ,"
    textline "                   "
    hexmask.long.byte 0x0 18.--18. 0x1 0x0 " SOAK_FAIL                 ,"
    textline "                   "
    hexmask.long.byte 0x0 24.--31. 0x1 0x0 " SOAK_CNT                  ,"

; ------------------------ CONF member of otp_sh ------------------------

  group 0x0004++0x0003
    line.long 0x000 "CONF, OTP Configuration register"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PWRUP                     ,"
    textline "                   "
    hexmask.long.byte 0x0 4.--5. 0x1 0x0 " AHB_CLK_RATIO             ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--8. 0x1 0x0 " FL_EVEN                   ,"
    textline "                   "
    hexmask.long.byte 0x0 9.--9. 0x1 0x0 " FL_ODD                    ,"
    textline "                   "
    hexmask.long.byte 0x0 10.--10. 0x1 0x0 " DIS_PF                    ,"
    textline "                   "
    hexmask.long.byte 0x0 11.--11. 0x1 0x0 " RED_EN                    ,Enable OTP redundancy"

; ------------------------ INSTR member of otp_sh ------------------------

  group 0x0008++0x0003
    line.long 0x000 "INSTR, Instruction Register"
    textline "                   "
    bitfld.long 0x0 0.--4. " OTP_INSTR                 ," "NONE (0),PROG_AND_VERIFY (1),READ (2),PROG (3),WRITE_OTP_DATA (4),SETMODE_MRA (5),CMP (6),PCH (7),BIST_RESET (8),BIST_STRESS_TEST (9),BIST_CLEAN_ARRAY_TEST (a),SETMODE_MRB (b),SETMODE_MR (c),%x..."
    textline "                   "
    hexmask.long.word 0x0 16.--28. 0x1 0x0 " OTP_ADDR                  ,"

; ------------------------ EXEC member of otp_sh ------------------------

  group 0x000C++0x0003
    line.long 0x000 "EXEC, Start Command Execution"
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " START_EXEC                ,"

; ----------------------- DATAW0 member of otp_sh -----------------------

  group 0x0010++0x0003
    line.long 0x000 "DATAW0, Write Data Register 0"
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " DATA                      ,Data to be written into selected OTP CacheLine word"

; ----------------------- DATAW1 member of otp_sh -----------------------

  group 0x0014++0x0003
    line.long 0x000 "DATAW1, Write Data Register 1"
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " DATA                      ,Data to be written into selected OTP CacheLine word"

; ----------------------- DATAW2 member of otp_sh -----------------------

  group 0x0018++0x0003
    line.long 0x000 "DATAW2, Write Data Register 2"
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " DATA                      ,Data to be written into selected OTP CacheLine word"

; ----------------------- DATAW3 member of otp_sh -----------------------

  group 0x001C++0x0003
    line.long 0x000 "DATAW3, Write Data Register 3"
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " DATA                      ,Data to be written into selected OTP CacheLine word"

; ---------------------- READ_MRAB member of otp_sh ----------------------

  group 0x0020++0x0003
    line.long 0x000 "READ_MRAB, MRA-MRB config register"
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " MRB_READ                  ,"
    textline "                   "
    hexmask.long.word 0x0 16.--31. 0x1 0x0 " MRA_READ                  ,"

; ----------------------- READ_MR member of otp_sh -----------------------

  group 0x0024++0x0003
    line.long 0x000 "READ_MR, MR config register"
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " MR_READ                   ,"

; --------------------- READ1_MRAB member of otp_sh ---------------------

  group 0x0028++0x0003
    line.long 0x000 "READ1_MRAB, MRA-MRB (1) config register"
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " MRB_READ1                 ,"
    textline "                   "
    hexmask.long.word 0x0 16.--31. 0x1 0x0 " MRA_READ1                 ,"

; ---------------------- READ1_MR member of otp_sh ----------------------

  group 0x002C++0x0003
    line.long 0x000 "READ1_MR, MR (1) config register"
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " MR_READ1                  ,"

; --------------------- READ2_MRAB member of otp_sh ---------------------

  group 0x0030++0x0003
    line.long 0x000 "READ2_MRAB, MRA-MRB (2) config register"
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " MRB_READ2                 ,"
    textline "                   "
    hexmask.long.word 0x0 16.--31. 0x1 0x0 " MRA_READ2                 ,"

; ---------------------- READ2_MR member of otp_sh ----------------------

  group 0x0034++0x0003
    line.long 0x000 "READ2_MR, MR (2) config register"
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " MR_READ2                  ,"

; ---------------------- OPT_MRAB member of otp_sh ----------------------

  rgroup 0x0038++0x0003
    line.long 0x000 "OPT_MRAB, MRA-MRB status report"
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " OTP_MRA                   ,"
    textline "                   "
    hexmask.long.word 0x0 16.--31. 0x1 0x0 " OTP_MRB                   ,"

; ----------------------- OPT_MR member of otp_sh -----------------------

  rgroup 0x003C++0x0003
    line.long 0x000 "OPT_MR, MR status report"
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " OTP_MR                    ,"

; ----------------------- OTP_Q0 member of otp_sh -----------------------

  rgroup 0x0040++0x0003
    line.long 0x000 "OTP_Q0, Read Data Register 0"
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " DATA                      ,Data read from selected OTP CacheLine word"

; ----------------------- OTP_Q1 member of otp_sh -----------------------

  rgroup 0x0044++0x0003
    line.long 0x000 "OTP_Q1, Read Data Register 1"
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " DATA                      ,Data read from selected OTP CacheLine word"

; ----------------------- OTP_Q2 member of otp_sh -----------------------

  rgroup 0x0048++0x0003
    line.long 0x000 "OTP_Q2, Read Data Register 2"
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " DATA                      ,Data read from selected OTP CacheLine word"

; ----------------------- OTP_Q3 member of otp_sh -----------------------

  rgroup 0x004C++0x0003
    line.long 0x000 "OTP_Q3, Read Data Register 3"
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " DATA                      ,Data read from selected OTP CacheLine word"

; ----------------------- INT_RAW member of otp_sh -----------------------

  rgroup 0x0050++0x0003
    line.long 0x000 "INT_RAW, Interrupt Raw register."
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PWR_STAT                  ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " RAW_INSTR_DONE            ,"
    textline "                   "
    hexmask.long.byte 0x0 2.--2. 0x1 0x0 " RAW_READ_FAULT            ,"
    textline "                   "
    hexmask.long.byte 0x0 3.--3. 0x1 0x0 " RAW_PROG_FAULT            ,OTP programming at row SR fail"

; ---------------------- INT_MASK member of otp_sh ----------------------

  group 0x0054++0x0003
    line.long 0x000 "INT_MASK, Interrupt Mask register."
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " MSK_PWR_STAT              ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " MSK_INSTR_DONE            ,"
    textline "                   "
    hexmask.long.byte 0x0 2.--2. 0x1 0x0 " MSK_READ_FAULT            ,"
    textline "                   "
    hexmask.long.byte 0x0 3.--3. 0x1 0x0 " MSK_PROG_FAULT            ,OTP programming at row SR fail"

; --------------------- INT_ACTIVE member of otp_sh ---------------------

  rgroup 0x0058++0x0003
    line.long 0x000 "INT_ACTIVE, Interrupt Active Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PWR_STAT                  ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " INSTR_DONE                ,"
    textline "                   "
    hexmask.long.byte 0x0 2.--2. 0x1 0x0 " READ_FAULT                ,"
    textline "                   "
    hexmask.long.byte 0x0 3.--3. 0x1 0x0 " PROG_FAULT                ,"

; ------------------- INT_ACTIVE_CLR member of otp_sh -------------------

  group 0x005C++0x0003
    line.long 0x000 "INT_ACTIVE_CLR, Interrupt Active Clear Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " PWR_STAT                  ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " INSTR_DONE                ,"
    textline "                   "
    hexmask.long.byte 0x0 2.--2. 0x1 0x0 " READ_FAULT                ,"
    textline "                   "
    hexmask.long.byte 0x0 3.--3. 0x1 0x0 " PROG_FAULT                ,"

; --------------------- OTP_PWRUP_C member of otp_sh ---------------------

  group 0x0060++0x0003
    line.long 0x000 "OTP_PWRUP_C, Powerup configuration register"
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " TPUR_PSR                  ,Clear bit for BOOT_FAIL_FAULT Interrupt."
    textline "                   "
    hexmask.long.byte 0x0 16.--23. 0x1 0x0 " TRESR                     ,Clear bit for BOOT_FAIL_FAULT Interrupt."

; --------------------- OTP_PROG_C member of otp_sh ---------------------

  group 0x0064++0x0003
    line.long 0x000 "OTP_PROG_C, Programming configuration register"
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " PROG_SOAK_PULSE           ,"
    textline "                   "
    hexmask.long.word 0x0 16.--31. 0x1 0x0 " PROG_PULSE                ,"

; ---------------------- OTP_CP_C member of otp_sh ----------------------

  group 0x0068++0x0003
    line.long 0x000 "OTP_CP_C, Charge pump configuration register"
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " VPP_WARMDOWN              ,"
    textline "                   "
    hexmask.long.word 0x0 16.--24. 0x1 0x0 " VPP_WARMUP                ,"

; --------------------- OTP_READ_C member of otp_sh ---------------------

  group 0x006C++0x0003
    line.long 0x000 "OTP_READ_C, Read configuration register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " READ_TIMEOUT              ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " BIST_READ_TIMEOUT         ,"
    textline "                   "
    hexmask.long.byte 0x0 16.--20. 0x1 0x0 " PROG_RECOVERY_TIME        ,"
    textline "                   "
    hexmask.long.byte 0x0 24.--31. 0x1 0x0 " MAXCNT_SOAK               ,"

; ----------------------- ERR_RPT member of otp_sh -----------------------

  rgroup 0x0070++0x0003
    line.long 0x000 "ERR_RPT, Error Report Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " AHB_ILL_APB_ACC           ,Report the illegal bit status"
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " AHB_ILL_WR                ,Report the illegal bit status"
    textline "                   "
    hexmask.long.word 0x0 16.--27. 0x1 0x0 " OTP_ADDR                  ,Reflect the status of the selected group of signals        OTP address causing illegal access"

; --------------------- ERR_RPT_CLR member of otp_sh ---------------------

  group 0x0074++0x0003
    line.long 0x000 "ERR_RPT_CLR, Error Report Register"
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " CLR                       ,Report the illegal bit status"

; --------------------- OTP_BIST_C member of otp_sh ---------------------

  group 0x0078++0x0003
    line.long 0x000 "OTP_BIST_C, Bist status and control register"
    textline "                   "
    bitfld.long 0x0 0.--2. " BMODE_SEL                 ," "MAIN (0),BOOT (1),RDNT (2),%d..."
    textline "                   "
    hexmask.long.byte 0x0 4.--4. 0x1 0x0 " BBUSY                     ,"
    textline "                   "
    hexmask.long.byte 0x0 5.--5. 0x1 0x0 " BFAIL                     ,"
    textline "                   "
    hexmask.long.byte 0x0 6.--6. 0x1 0x0 " BDONE                     ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " BFAIL0                    ,"
    textline "                   "
    hexmask.long.byte 0x0 10.--11. 0x1 0x0 " BFAIL1                    ,"
    textline "                   "
    hexmask.long.byte 0x0 12.--12. 0x1 0x0 " BFAIL2                    ,"
    textline "                   "
    hexmask.long.word 0x0 16.--28. 0x1 0x0 " BIST_ADDR_FAIL            ,"

tree.end

; -------------------------------------------------------------------
; End Block - otp_sh
; -------------------------------------------------------------------
tree.end
; @file:      pid.per
; Chip name:  SHASTA
; Module:     pid
; 
; Generated by the pmm metagen library.
;
; ===================================================================
; Copyright (C) 2018 Infineon Technologies AG
; All rights reserved.
; ===================================================================
;
; ===================================================================
; This document contains proprietary information. Passing on and
; copying of this document, and communication of its contents is not
; permitted without prior written authorisation.
; ===================================================================

; This file is automatically generated. Do not edit!


config 32. 8.
width 20.

tree "Block - pid"
; -------------------------------------------------------------------
; Begin Block - pid
; -------------------------------------------------------------------
base D:0x70001C00

tree "pid0"
; ---------------------- PID_FF_CFG1 member of pid ----------------------

  group 0x0000++0x0003
    line.long 0x000 "PID_FF_CFG1, Feed forward adjustment for dead time.  Note adjustment always positive because dead time always reduces duty cycle."
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " pid_ff_dt_adj             ,Feed forward adjustment for dead time.  Note adjustment always positive because dead time always reduces duty cycle."
    textline "                   "
    hexmask.long.byte 0x0 8.--12. 0x1 0x0 " pid_kp_ff_lpf             ,PID feed forward LPF coefficient. "
    textline "                   "
    hexmask.long.byte 0x0 13.--17. 0x1 0x0 " pid_ff_gain_scale         ,Feed forward gain scale.  The typical setting is 16 which corresponds to a gain of 1.0."
    textline "                   "
    hexmask.long.byte 0x0 18.--19. 0x1 0x0 " pid_ff_vrect_sel          ,Feed forward Vrect source select where feed forward is computed as (Vout / Vrect).  Note that the feed forward computation my be overriden by pid_ff_override_sel. "
    textline "                   "
    hexmask.long.byte 0x0 20.--27. 0x1 0x0 " pid_vrect_ref             ,Reference rectification voltage for PID coefficient scaling."

; ----------------------- PID_COEFF member of pid -----------------------

  group 0x0004++0x0003
    line.long 0x000 "PID_COEFF, PID pre-filter coefficient index.  Note that index settings greater than 55 are clamped to 55. "
    textline "                   "
    hexmask.long.byte 0x0 0.--5. 0x1 0x0 " pid_kfp1_index_1ph        ,PID pre-filter coefficient index.  Note that index settings greater than 55 are clamped to 55. "
    textline "                   "
    hexmask.long.byte 0x0 6.--11. 0x1 0x0 " pid_kfp2_index_1ph        ,PID post-filter coefficient index.  Note that index settings greater than 55 are clamped to 55. "
    textline "                   "
    hexmask.long.byte 0x0 12.--17. 0x1 0x0 " pid_kp_index_1ph          ,PID proportional coefficient index.  Note that index settings greater than 55 are clamped to 55. "
    textline "                   "
    hexmask.long.byte 0x0 18.--23. 0x1 0x0 " pid_ki_index_1ph          ,PID integral coefficient index.  Note that index settings greater than 55 are clamped to 55. "
    textline "                   "
    hexmask.long.byte 0x0 24.--30. 0x1 0x0 " pid_kd_index_1ph          ,PID derivative coefficient index.  Note that index settings greater than 119 are clamped to 119. "

; ----------------------- PID_FORCE member of pid -----------------------

  group 0x0008++0x0003
    line.long 0x000 "PID_FORCE, Forced duty cycle value overrides PID output when selected by pid_force_duty_en.  Since this force is applied at the PID output, downstream adjustments to the duty cycle such as current balance in an interleaved (multi-phase) design are still applied.  To also override the current balance adjust use pwm.ramp0_force_duty or pwm.ramp1_force_duty."
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " pid_force_duty            ,Forced duty cycle value overrides PID output when selected by pid_force_duty_en.  Since this force is applied at the PID output, downstream adjustments to the duty cycle such as current balance in an interleaved (multi-phase) design are still applied.  To also override the current balance adjust use pwm.ramp0_force_duty or pwm.ramp1_force_duty."
    textline "                   "
    hexmask.long.byte 0x0 8.--8. 0x1 0x0 " pid_force_duty_en         ,Forced duty cycle select. "

; ----------------------- PID_TRANS member of pid -----------------------

  group 0x000C++0x0003
    line.long 0x000 "PID_TRANS, Error voltage threshold for exiting fast transient mode where the error voltage is defined as (target voltage - sense voltage).  When (error voltage  This threshold is always positive indicating the controller exits fast transient mode prior to the sensed voltage overshooting the target."
    textline "                   "
    hexmask.long.byte 0x0 0.--6. 0x1 0x0 " pid_verr_exit_thrs        ,Error voltage threshold for exiting fast transient mode where the error voltage is defined as (target voltage - sense voltage).  When (error voltage  This threshold is always positive indicating the controller exits fast transient mode prior to the sensed voltage overshooting the target."
    textline "                   "
    hexmask.long.byte 0x0 7.--13. 0x1 0x0 " pid_verr_slope_exit_thrs  ,Error voltage slope threshold for exiting fast transient mode where the error voltage is defined as (target voltage - sense voltage).  When (error voltage  1. This threshold is always negative indicating the controller does not exit fast transient mode until the sensed voltage has hit its maximum undershoot and is approaching the target voltage. 2. There is a -1.25mV offset (i.e., code 0 = -1.25mV, 1 = -2.5mV, ...)"
    textline "                   "
    hexmask.long.byte 0x0 14.--20. 0x1 0x0 " pid_verr_entry_thrs       ,Error voltage threshold for entering fast transient mode where the error voltage is defined as (target voltage - sense voltage).  When (error voltage > pid_verr_entry_thrs) AND (error voltage slope > pid_verr_slope_entry_thrs) the control loop enters fast transient mode.   1. This threshold is always positive indicating the controller enters fast transient mode only when the sensed voltage is below the target. 2. Setting pid_verr_entry_thrs=0 disables fast transient mode."
    textline "                   "
    hexmask.long.byte 0x0 21.--27. 0x1 0x0 " pid_verr_slope_entry_thrs ,Error voltage slope threshold for entering fast transient mode where the error voltage is defined as (target voltage - sense voltage).  When (error voltage > pid_verr_entry_thrs) AND (error voltage slope > pid_verr_slope_entry_thrs) the control loop enters fast transient mode.   This threshold is always positive indicating the controller enters fast transient mode as the sensed voltage is decreasing towards maximum undershoot."
    textline "                   "
    hexmask.long.byte 0x0 28.--30. 0x1 0x0 " pid_ftr_lpf               ,Fast transient mode filter bandwidth on error voltage input. "

; ------------------------ PID_OVS member of pid ------------------------

  group 0x0010++0x0003
    line.long 0x000 "PID_OVS, Error voltage threshold for exiting overshoot transient mode where the error voltage is defined as (target voltage - sense voltage).  When (error voltage > pid_ovs_exit_thrs) AND (error voltage slope > pid_ovs_slope_exit_thrs) the control loop exits overshoot transient mode.   1. This threshold is always negative indicating the controller exits overshoot transient mode prior to the sensed voltage undershooting the target. 2. There is a -1.25mV offset (i.e., code 0 = -1.25mV, 1 = -2.5mV, ...)"
    textline "                   "
    hexmask.long.byte 0x0 0.--6. 0x1 0x0 " pid_ovs_exit_thrs         ,Error voltage threshold for exiting overshoot transient mode where the error voltage is defined as (target voltage - sense voltage).  When (error voltage > pid_ovs_exit_thrs) AND (error voltage slope > pid_ovs_slope_exit_thrs) the control loop exits overshoot transient mode.   1. This threshold is always negative indicating the controller exits overshoot transient mode prior to the sensed voltage undershooting the target. 2. There is a -1.25mV offset (i.e., code 0 = -1.25mV, 1 = -2.5mV, ...)"
    textline "                   "
    hexmask.long.byte 0x0 7.--13. 0x1 0x0 " pid_ovs_slope_exit_thrs   ,Error voltage slope threshold for exiting overshoot transient mode where the error voltage is defined as (target voltage - sense voltage).  When (error voltage > pid_ovs_exit_thrs) AND (error voltage slope > pid_ovs_slope_exit_thrs) the control loop exits overshoot transient mode.  This threshold is always positive indicating the controller does not exit overshoot transient mode until the sensed voltage has hit its maximum overshoot and is approaching the target voltage."
    textline "                   "
    hexmask.long.byte 0x0 14.--20. 0x1 0x0 " pid_ovs_entry_thrs        ,Error voltage threshold for entering overshoot transient mode where the error voltage is defined as (target voltage - sense voltage).  When (error voltage   1. This threshold is always negative indicating the controller enters overshoot transient mode only when the sensed voltage is above the target. 2. Setting pid_ovs_entry_thrs=0 disables overshoot transient mode. 3. There is a -1.25mV offset (i.e., code 0 = -1.25mV, 1 = -2.5mV, ...)"
    textline "                   "
    hexmask.long.byte 0x0 21.--27. 0x1 0x0 " pid_ovs_slope_entry_thrs  ,Error voltage slope threshold for entering overshoot transient mode where the error voltage is defined as (target voltage - sense voltage).  When (error voltage   1. This threshold is always negative indicating the controller enters overshoot transient mode as the sensed voltage is increasing towards maximum overshoot. 2. There is a -1.25mV offset (i.e., code 0 = -1.25mV, 1 = -2.5mV, ...)"

; ----------------------- PID_BURST member of pid -----------------------

  group 0x0014++0x0003
    line.long 0x000 "PID_BURST, Burst mode error voltage threshold where the error voltage is defined as (target voltage - sense voltage).  When the controller is in burst mode, (error voltage > pid_burst_mode_err_thr) will trigger the start of a new burst sequence.   This threshold is always positive indicating the controller triggers the start of a new burst sequence at or below the target voltage."
    textline "                   "
    hexmask.long.byte 0x0 0.--3. 0x1 0x0 " pid_burst_mode_err_thr    ,Burst mode error voltage threshold where the error voltage is defined as (target voltage - sense voltage).  When the controller is in burst mode, (error voltage > pid_burst_mode_err_thr) will trigger the start of a new burst sequence.   This threshold is always positive indicating the controller triggers the start of a new burst sequence at or below the target voltage."
    textline "                   "
    hexmask.long.byte 0x0 4.--9. 0x1 0x0 " pid_burst_mode_ith        ,Burst mode entry current threshold.  When burst mode is enabled (POWER_MODE[7:0]=0x00), the controller will enter burst mode upon the sensed current dropping below pid_burst_mode_ith.  LSB = (Qadc / 2) where Qadc is value of MFR_IOUT_APC in Amps"
    textline "                   "
    hexmask.long.byte 0x0 10.--11. 0x1 0x0 " pid_burst_reps            ,Burst mode cycle count.  In Burst Mode, 1 cycle corresponds to 1 even half cycle pulse followed by 1 odd half cycle pulse.  This register defines the number of burst cycles in each burst event.  A higher cycle count can be used to increase the inductor peak current in a burst event which will increase the time between burst events at a given load current. "

; ---------------------- PID_OSP_CFG1 member of pid ----------------------

  group 0x0018++0x0003
    line.long 0x000 "PID_OSP_CFG1, Defines the minimum PID feed forward value, above which to begin checking for an open sense fault during soft start.  This fault will indicate a larger than expected impedance between Vout and Vout_sen."
    textline "                   "
    hexmask.long.byte 0x0 0.--6. 0x1 0x0 " pid_osp_ff_thr            ,Defines the minimum PID feed forward value, above which to begin checking for an open sense fault during soft start.  This fault will indicate a larger than expected impedance between Vout and Vout_sen."
    textline "                   "
    hexmask.long.byte 0x0 7.--13. 0x1 0x0 " pid_osp_duty_thr          ,Defines the minimum PID duty cycle value, above which to begin checking for an open sense fault during soft start.  This fault will indicate a larger than expected impedance between Vout and Vout_sen."
    textline "                   "
    hexmask.long.byte 0x0 14.--17. 0x1 0x0 " pid_osp_ff_scale          ,Scale factor applied to PID feed forward term to detect an open sense fault between Vout and Vout_sen during soft start.  A setting of 0 will disable this fault check."

; ---------------------- PID_FF_CFG2 member of pid ----------------------

  group 0x001C++0x0003
    line.long 0x000 "PID_FF_CFG2, Vrect override for PID feed forward computation in internal VS ADC format.  Used only when selected by pid_ff_vrect_sel. Computed from PMBus commands as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--11. 0x1 0x0 " pid_ff_vrect_override     ,Vrect override for PID feed forward computation in internal VS ADC format.  Used only when selected by pid_ff_vrect_sel. Computed from PMBus commands as follows: "

; ---------------------- PID_FF_CFG4 member of pid ----------------------

  group 0x0020++0x0003
    line.long 0x000 "PID_FF_CFG4, PID feed forward override value.  Used when selected by pid_ff_override_sel."
    textline "                   "
    hexmask.long.word 0x0 0.--9. 0x1 0x0 " pid_ff_override           ,PID feed forward override value.  Used when selected by pid_ff_override_sel."
    textline "                   "
    hexmask.long.byte 0x0 10.--10. 0x1 0x0 " pid_ff_override_sel       ,PID feed forward override select. "

; ---------------------- PID_FF_CFG3 member of pid ----------------------

  group 0x0024++0x0003
    line.long 0x000 "PID_FF_CFG3, Conversion factor for computing Vout from the measured VS ADC output. Computed from PMBus commands as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--8. 0x1 0x0 " pid_ff_one_div_vout_scal? ,Conversion factor for computing Vout from the measured VS ADC output. Computed from PMBus commands as follows: "
    textline "                   "
    hexmask.long.long 0x0 9.--27. 0x1 0x0 " pid_ff_i82_div_trans_sca? ,Conversion factor for computing 1/Vrect from the Telemtry Sense ADC Vin measurement. Computed from PMBus commands as follows: "

; ----------------------- PID_COEFF2 member of pid -----------------------

  rgroup 0x0028++0x0003
    line.long 0x000 "PID_COEFF2, PID Kp coefficient after Vin scaling.  See pid_kp_index_1ph description for definition."
    textline "                   "
    hexmask.long.byte 0x0 0.--5. 0x1 0x0 " pid_kp_eff                ,PID Kp coefficient after Vin scaling.  See pid_kp_index_1ph description for definition."
    textline "                   "
    hexmask.long.byte 0x0 6.--11. 0x1 0x0 " pid_ki_eff                ,PID Ki coefficient after Vin scaling.  See pid_ki_index_1ph description for definition."
    textline "                   "
    hexmask.long.byte 0x0 12.--18. 0x1 0x0 " pid_kd_eff                ,PID Kd coefficient after Vin scaling.  See pid_kd_index_1ph description for definition."

; -------------------- PID_RESET_ACCUM member of pid --------------------

  group 0x002C++0x0003
    line.long 0x000 "PID_RESET_ACCUM, PID integral term accumulator reset.  Allows FW to reset the accumulator by first writing a 1 to reset the accumulator followed by writing a 0 to release the reset. "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " pid_reset_accum           ,PID integral term accumulator reset.  Allows FW to reset the accumulator by first writing a 1 to reset the accumulator followed by writing a 0 to release the reset. "

; -------------------- PID_FREEZE_ACCUM member of pid --------------------

  group 0x0030++0x0003
    line.long 0x000 "PID_FREEZE_ACCUM, PID integral term accumulator freeze control.  Allows FW to hold the accumulator at its current value by writing a 1 until it is released by writing a 0. "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " pid_freeze_accum          ,PID integral term accumulator freeze control.  Allows FW to hold the accumulator at its current value by writing a 1 until it is released by writing a 0. "

; ---------------------- PID_OSP_CFG2 member of pid ----------------------

  group 0x0034++0x0003
    line.long 0x000 "PID_OSP_CFG2, Threshold applied to VS output during current source based open sense check to declare fault.  Should be set to approximately (1.5 * Rvout_gnd * 100uA / 20mV) where Rvout_gnd_max = 10KOhm. A setting of 0 will disable this fault check."
    textline "                   "
    hexmask.long.byte 0x0 0.--6. 0x1 0x0 " pid_osp_vout_thr          ,Threshold applied to VS output during current source based open sense check to declare fault.  Should be set to approximately (1.5 * Rvout_gnd * 100uA / 20mV) where Rvout_gnd_max = 10KOhm. A setting of 0 will disable this fault check."

; ---------------------- PID_OSP_CFG3 member of pid ----------------------

  group 0x0038++0x0003
    line.long 0x000 "PID_OSP_CFG3, Threshold applied to VRS output during current source based open sense check to declare fault.  Should be set to approximately (1.5 * Rvrect_gnd * 100uA / 20mV) where Rvrect_gnd_max = 10KOhm.  A setting of 0 will disable this fault check."
    textline "                   "
    hexmask.long.byte 0x0 0.--6. 0x1 0x0 " pid_osp_vrect_thr         ,Threshold applied to VRS output during current source based open sense check to declare fault.  Should be set to approximately (1.5 * Rvrect_gnd * 100uA / 20mV) where Rvrect_gnd_max = 10KOhm.  A setting of 0 will disable this fault check."

; ---------------------- PID_OSP_CFG4 member of pid ----------------------

  group 0x003C++0x0003
    line.long 0x000 "PID_OSP_CFG4, Wait time for current source to settle in current source based open sense check."
    textline "                   "
    hexmask.long.byte 0x0 0.--3. 0x1 0x0 " pid_osp_cur_wait          ,Wait time for current source to settle in current source based open sense check."

; ------------------------ PID_DUTY member of pid ------------------------

  rgroup 0x0040++0x0003
    line.long 0x000 "PID_DUTY, PID duty cycle at sample rate (50MHz)"
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " pid_duty                  ,PID duty cycle at sample rate (50MHz)"

; ------------------------- PID_FF member of pid -------------------------

  rgroup 0x0044++0x0003
    line.long 0x000 "PID_FF, PID feed forward at sample rate (50MHz)"
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " pid_ff_duty_lpf           ,PID feed forward at sample rate (50MHz)"

tree.end
base D:0x70002000

tree "pid1"
; ---------------------- PID_FF_CFG1 member of pid ----------------------

  group 0x0000++0x0003
    line.long 0x000 "PID_FF_CFG1, Feed forward adjustment for dead time.  Note adjustment always positive because dead time always reduces duty cycle."
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " pid_ff_dt_adj             ,Feed forward adjustment for dead time.  Note adjustment always positive because dead time always reduces duty cycle."
    textline "                   "
    hexmask.long.byte 0x0 8.--12. 0x1 0x0 " pid_kp_ff_lpf             ,PID feed forward LPF coefficient. "
    textline "                   "
    hexmask.long.byte 0x0 13.--17. 0x1 0x0 " pid_ff_gain_scale         ,Feed forward gain scale.  The typical setting is 16 which corresponds to a gain of 1.0."
    textline "                   "
    hexmask.long.byte 0x0 18.--19. 0x1 0x0 " pid_ff_vrect_sel          ,Feed forward Vrect source select where feed forward is computed as (Vout / Vrect).  Note that the feed forward computation my be overriden by pid_ff_override_sel. "
    textline "                   "
    hexmask.long.byte 0x0 20.--27. 0x1 0x0 " pid_vrect_ref             ,Reference rectification voltage for PID coefficient scaling."

; ----------------------- PID_COEFF member of pid -----------------------

  group 0x0004++0x0003
    line.long 0x000 "PID_COEFF, PID pre-filter coefficient index.  Note that index settings greater than 55 are clamped to 55. "
    textline "                   "
    hexmask.long.byte 0x0 0.--5. 0x1 0x0 " pid_kfp1_index_1ph        ,PID pre-filter coefficient index.  Note that index settings greater than 55 are clamped to 55. "
    textline "                   "
    hexmask.long.byte 0x0 6.--11. 0x1 0x0 " pid_kfp2_index_1ph        ,PID post-filter coefficient index.  Note that index settings greater than 55 are clamped to 55. "
    textline "                   "
    hexmask.long.byte 0x0 12.--17. 0x1 0x0 " pid_kp_index_1ph          ,PID proportional coefficient index.  Note that index settings greater than 55 are clamped to 55. "
    textline "                   "
    hexmask.long.byte 0x0 18.--23. 0x1 0x0 " pid_ki_index_1ph          ,PID integral coefficient index.  Note that index settings greater than 55 are clamped to 55. "
    textline "                   "
    hexmask.long.byte 0x0 24.--30. 0x1 0x0 " pid_kd_index_1ph          ,PID derivative coefficient index.  Note that index settings greater than 119 are clamped to 119. "

; ----------------------- PID_FORCE member of pid -----------------------

  group 0x0008++0x0003
    line.long 0x000 "PID_FORCE, Forced duty cycle value overrides PID output when selected by pid_force_duty_en.  Since this force is applied at the PID output, downstream adjustments to the duty cycle such as current balance in an interleaved (multi-phase) design are still applied.  To also override the current balance adjust use pwm.ramp0_force_duty or pwm.ramp1_force_duty."
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " pid_force_duty            ,Forced duty cycle value overrides PID output when selected by pid_force_duty_en.  Since this force is applied at the PID output, downstream adjustments to the duty cycle such as current balance in an interleaved (multi-phase) design are still applied.  To also override the current balance adjust use pwm.ramp0_force_duty or pwm.ramp1_force_duty."
    textline "                   "
    hexmask.long.byte 0x0 8.--8. 0x1 0x0 " pid_force_duty_en         ,Forced duty cycle select. "

; ----------------------- PID_TRANS member of pid -----------------------

  group 0x000C++0x0003
    line.long 0x000 "PID_TRANS, Error voltage threshold for exiting fast transient mode where the error voltage is defined as (target voltage - sense voltage).  When (error voltage  This threshold is always positive indicating the controller exits fast transient mode prior to the sensed voltage overshooting the target."
    textline "                   "
    hexmask.long.byte 0x0 0.--6. 0x1 0x0 " pid_verr_exit_thrs        ,Error voltage threshold for exiting fast transient mode where the error voltage is defined as (target voltage - sense voltage).  When (error voltage  This threshold is always positive indicating the controller exits fast transient mode prior to the sensed voltage overshooting the target."
    textline "                   "
    hexmask.long.byte 0x0 7.--13. 0x1 0x0 " pid_verr_slope_exit_thrs  ,Error voltage slope threshold for exiting fast transient mode where the error voltage is defined as (target voltage - sense voltage).  When (error voltage  1. This threshold is always negative indicating the controller does not exit fast transient mode until the sensed voltage has hit its maximum undershoot and is approaching the target voltage. 2. There is a -1.25mV offset (i.e., code 0 = -1.25mV, 1 = -2.5mV, ...)"
    textline "                   "
    hexmask.long.byte 0x0 14.--20. 0x1 0x0 " pid_verr_entry_thrs       ,Error voltage threshold for entering fast transient mode where the error voltage is defined as (target voltage - sense voltage).  When (error voltage > pid_verr_entry_thrs) AND (error voltage slope > pid_verr_slope_entry_thrs) the control loop enters fast transient mode.   1. This threshold is always positive indicating the controller enters fast transient mode only when the sensed voltage is below the target. 2. Setting pid_verr_entry_thrs=0 disables fast transient mode."
    textline "                   "
    hexmask.long.byte 0x0 21.--27. 0x1 0x0 " pid_verr_slope_entry_thrs ,Error voltage slope threshold for entering fast transient mode where the error voltage is defined as (target voltage - sense voltage).  When (error voltage > pid_verr_entry_thrs) AND (error voltage slope > pid_verr_slope_entry_thrs) the control loop enters fast transient mode.   This threshold is always positive indicating the controller enters fast transient mode as the sensed voltage is decreasing towards maximum undershoot."
    textline "                   "
    hexmask.long.byte 0x0 28.--30. 0x1 0x0 " pid_ftr_lpf               ,Fast transient mode filter bandwidth on error voltage input. "

; ------------------------ PID_OVS member of pid ------------------------

  group 0x0010++0x0003
    line.long 0x000 "PID_OVS, Error voltage threshold for exiting overshoot transient mode where the error voltage is defined as (target voltage - sense voltage).  When (error voltage > pid_ovs_exit_thrs) AND (error voltage slope > pid_ovs_slope_exit_thrs) the control loop exits overshoot transient mode.   1. This threshold is always negative indicating the controller exits overshoot transient mode prior to the sensed voltage undershooting the target. 2. There is a -1.25mV offset (i.e., code 0 = -1.25mV, 1 = -2.5mV, ...)"
    textline "                   "
    hexmask.long.byte 0x0 0.--6. 0x1 0x0 " pid_ovs_exit_thrs         ,Error voltage threshold for exiting overshoot transient mode where the error voltage is defined as (target voltage - sense voltage).  When (error voltage > pid_ovs_exit_thrs) AND (error voltage slope > pid_ovs_slope_exit_thrs) the control loop exits overshoot transient mode.   1. This threshold is always negative indicating the controller exits overshoot transient mode prior to the sensed voltage undershooting the target. 2. There is a -1.25mV offset (i.e., code 0 = -1.25mV, 1 = -2.5mV, ...)"
    textline "                   "
    hexmask.long.byte 0x0 7.--13. 0x1 0x0 " pid_ovs_slope_exit_thrs   ,Error voltage slope threshold for exiting overshoot transient mode where the error voltage is defined as (target voltage - sense voltage).  When (error voltage > pid_ovs_exit_thrs) AND (error voltage slope > pid_ovs_slope_exit_thrs) the control loop exits overshoot transient mode.  This threshold is always positive indicating the controller does not exit overshoot transient mode until the sensed voltage has hit its maximum overshoot and is approaching the target voltage."
    textline "                   "
    hexmask.long.byte 0x0 14.--20. 0x1 0x0 " pid_ovs_entry_thrs        ,Error voltage threshold for entering overshoot transient mode where the error voltage is defined as (target voltage - sense voltage).  When (error voltage   1. This threshold is always negative indicating the controller enters overshoot transient mode only when the sensed voltage is above the target. 2. Setting pid_ovs_entry_thrs=0 disables overshoot transient mode. 3. There is a -1.25mV offset (i.e., code 0 = -1.25mV, 1 = -2.5mV, ...)"
    textline "                   "
    hexmask.long.byte 0x0 21.--27. 0x1 0x0 " pid_ovs_slope_entry_thrs  ,Error voltage slope threshold for entering overshoot transient mode where the error voltage is defined as (target voltage - sense voltage).  When (error voltage   1. This threshold is always negative indicating the controller enters overshoot transient mode as the sensed voltage is increasing towards maximum overshoot. 2. There is a -1.25mV offset (i.e., code 0 = -1.25mV, 1 = -2.5mV, ...)"

; ----------------------- PID_BURST member of pid -----------------------

  group 0x0014++0x0003
    line.long 0x000 "PID_BURST, Burst mode error voltage threshold where the error voltage is defined as (target voltage - sense voltage).  When the controller is in burst mode, (error voltage > pid_burst_mode_err_thr) will trigger the start of a new burst sequence.   This threshold is always positive indicating the controller triggers the start of a new burst sequence at or below the target voltage."
    textline "                   "
    hexmask.long.byte 0x0 0.--3. 0x1 0x0 " pid_burst_mode_err_thr    ,Burst mode error voltage threshold where the error voltage is defined as (target voltage - sense voltage).  When the controller is in burst mode, (error voltage > pid_burst_mode_err_thr) will trigger the start of a new burst sequence.   This threshold is always positive indicating the controller triggers the start of a new burst sequence at or below the target voltage."
    textline "                   "
    hexmask.long.byte 0x0 4.--9. 0x1 0x0 " pid_burst_mode_ith        ,Burst mode entry current threshold.  When burst mode is enabled (POWER_MODE[7:0]=0x00), the controller will enter burst mode upon the sensed current dropping below pid_burst_mode_ith.  LSB = (Qadc / 2) where Qadc is value of MFR_IOUT_APC in Amps"
    textline "                   "
    hexmask.long.byte 0x0 10.--11. 0x1 0x0 " pid_burst_reps            ,Burst mode cycle count.  In Burst Mode, 1 cycle corresponds to 1 even half cycle pulse followed by 1 odd half cycle pulse.  This register defines the number of burst cycles in each burst event.  A higher cycle count can be used to increase the inductor peak current in a burst event which will increase the time between burst events at a given load current. "

; ---------------------- PID_OSP_CFG1 member of pid ----------------------

  group 0x0018++0x0003
    line.long 0x000 "PID_OSP_CFG1, Defines the minimum PID feed forward value, above which to begin checking for an open sense fault during soft start.  This fault will indicate a larger than expected impedance between Vout and Vout_sen."
    textline "                   "
    hexmask.long.byte 0x0 0.--6. 0x1 0x0 " pid_osp_ff_thr            ,Defines the minimum PID feed forward value, above which to begin checking for an open sense fault during soft start.  This fault will indicate a larger than expected impedance between Vout and Vout_sen."
    textline "                   "
    hexmask.long.byte 0x0 7.--13. 0x1 0x0 " pid_osp_duty_thr          ,Defines the minimum PID duty cycle value, above which to begin checking for an open sense fault during soft start.  This fault will indicate a larger than expected impedance between Vout and Vout_sen."
    textline "                   "
    hexmask.long.byte 0x0 14.--17. 0x1 0x0 " pid_osp_ff_scale          ,Scale factor applied to PID feed forward term to detect an open sense fault between Vout and Vout_sen during soft start.  A setting of 0 will disable this fault check."

; ---------------------- PID_FF_CFG2 member of pid ----------------------

  group 0x001C++0x0003
    line.long 0x000 "PID_FF_CFG2, Vrect override for PID feed forward computation in internal VS ADC format.  Used only when selected by pid_ff_vrect_sel. Computed from PMBus commands as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--11. 0x1 0x0 " pid_ff_vrect_override     ,Vrect override for PID feed forward computation in internal VS ADC format.  Used only when selected by pid_ff_vrect_sel. Computed from PMBus commands as follows: "

; ---------------------- PID_FF_CFG4 member of pid ----------------------

  group 0x0020++0x0003
    line.long 0x000 "PID_FF_CFG4, PID feed forward override value.  Used when selected by pid_ff_override_sel."
    textline "                   "
    hexmask.long.word 0x0 0.--9. 0x1 0x0 " pid_ff_override           ,PID feed forward override value.  Used when selected by pid_ff_override_sel."
    textline "                   "
    hexmask.long.byte 0x0 10.--10. 0x1 0x0 " pid_ff_override_sel       ,PID feed forward override select. "

; ---------------------- PID_FF_CFG3 member of pid ----------------------

  group 0x0024++0x0003
    line.long 0x000 "PID_FF_CFG3, Conversion factor for computing Vout from the measured VS ADC output. Computed from PMBus commands as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--8. 0x1 0x0 " pid_ff_one_div_vout_scal? ,Conversion factor for computing Vout from the measured VS ADC output. Computed from PMBus commands as follows: "
    textline "                   "
    hexmask.long.long 0x0 9.--27. 0x1 0x0 " pid_ff_i82_div_trans_sca? ,Conversion factor for computing 1/Vrect from the Telemtry Sense ADC Vin measurement. Computed from PMBus commands as follows: "

; ----------------------- PID_COEFF2 member of pid -----------------------

  rgroup 0x0028++0x0003
    line.long 0x000 "PID_COEFF2, PID Kp coefficient after Vin scaling.  See pid_kp_index_1ph description for definition."
    textline "                   "
    hexmask.long.byte 0x0 0.--5. 0x1 0x0 " pid_kp_eff                ,PID Kp coefficient after Vin scaling.  See pid_kp_index_1ph description for definition."
    textline "                   "
    hexmask.long.byte 0x0 6.--11. 0x1 0x0 " pid_ki_eff                ,PID Ki coefficient after Vin scaling.  See pid_ki_index_1ph description for definition."
    textline "                   "
    hexmask.long.byte 0x0 12.--18. 0x1 0x0 " pid_kd_eff                ,PID Kd coefficient after Vin scaling.  See pid_kd_index_1ph description for definition."

; -------------------- PID_RESET_ACCUM member of pid --------------------

  group 0x002C++0x0003
    line.long 0x000 "PID_RESET_ACCUM, PID integral term accumulator reset.  Allows FW to reset the accumulator by first writing a 1 to reset the accumulator followed by writing a 0 to release the reset. "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " pid_reset_accum           ,PID integral term accumulator reset.  Allows FW to reset the accumulator by first writing a 1 to reset the accumulator followed by writing a 0 to release the reset. "

; -------------------- PID_FREEZE_ACCUM member of pid --------------------

  group 0x0030++0x0003
    line.long 0x000 "PID_FREEZE_ACCUM, PID integral term accumulator freeze control.  Allows FW to hold the accumulator at its current value by writing a 1 until it is released by writing a 0. "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " pid_freeze_accum          ,PID integral term accumulator freeze control.  Allows FW to hold the accumulator at its current value by writing a 1 until it is released by writing a 0. "

; ---------------------- PID_OSP_CFG2 member of pid ----------------------

  group 0x0034++0x0003
    line.long 0x000 "PID_OSP_CFG2, Threshold applied to VS output during current source based open sense check to declare fault.  Should be set to approximately (1.5 * Rvout_gnd * 100uA / 20mV) where Rvout_gnd_max = 10KOhm. A setting of 0 will disable this fault check."
    textline "                   "
    hexmask.long.byte 0x0 0.--6. 0x1 0x0 " pid_osp_vout_thr          ,Threshold applied to VS output during current source based open sense check to declare fault.  Should be set to approximately (1.5 * Rvout_gnd * 100uA / 20mV) where Rvout_gnd_max = 10KOhm. A setting of 0 will disable this fault check."

; ---------------------- PID_OSP_CFG3 member of pid ----------------------

  group 0x0038++0x0003
    line.long 0x000 "PID_OSP_CFG3, Threshold applied to VRS output during current source based open sense check to declare fault.  Should be set to approximately (1.5 * Rvrect_gnd * 100uA / 20mV) where Rvrect_gnd_max = 10KOhm.  A setting of 0 will disable this fault check."
    textline "                   "
    hexmask.long.byte 0x0 0.--6. 0x1 0x0 " pid_osp_vrect_thr         ,Threshold applied to VRS output during current source based open sense check to declare fault.  Should be set to approximately (1.5 * Rvrect_gnd * 100uA / 20mV) where Rvrect_gnd_max = 10KOhm.  A setting of 0 will disable this fault check."

; ---------------------- PID_OSP_CFG4 member of pid ----------------------

  group 0x003C++0x0003
    line.long 0x000 "PID_OSP_CFG4, Wait time for current source to settle in current source based open sense check."
    textline "                   "
    hexmask.long.byte 0x0 0.--3. 0x1 0x0 " pid_osp_cur_wait          ,Wait time for current source to settle in current source based open sense check."

; ------------------------ PID_DUTY member of pid ------------------------

  rgroup 0x0040++0x0003
    line.long 0x000 "PID_DUTY, PID duty cycle at sample rate (50MHz)"
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " pid_duty                  ,PID duty cycle at sample rate (50MHz)"

; ------------------------- PID_FF member of pid -------------------------

  rgroup 0x0044++0x0003
    line.long 0x000 "PID_FF, PID feed forward at sample rate (50MHz)"
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " pid_ff_duty_lpf           ,PID feed forward at sample rate (50MHz)"

tree.end

; -------------------------------------------------------------------
; End Block - pid
; -------------------------------------------------------------------
tree.end
; @file:      pmbus.per
; Chip name:  SHASTA
; Module:     pmbus
; 
; Generated by the pmm metagen library.
;
; ===================================================================
; Copyright (C) 2018 Infineon Technologies AG
; All rights reserved.
; ===================================================================
;
; ===================================================================
; This document contains proprietary information. Passing on and
; copying of this document, and communication of its contents is not
; permitted without prior written authorisation.
; ===================================================================

; This file is automatically generated. Do not edit!


config 32. 8.
width 20.

tree "Block - pmbus"
; -------------------------------------------------------------------
; Begin Block - pmbus
; -------------------------------------------------------------------
base D:0x70080000

tree "pmbus"
; ------------------------ STATUS member of pmbus ------------------------

  rgroup 0x0000++0x0003
    line.long 0x000 "STATUS, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " BUSY                      ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " DIRECTION                 ,"
    textline "                   "
    hexmask.long.byte 0x0 2.--2. 0x1 0x0 " ACK_STATUS                ,"
    textline "                   "
    hexmask.long.byte 0x0 3.--3. 0x1 0x0 " TOO_FEW_BITS              ,"
    textline "                   "
    hexmask.long.byte 0x0 4.--7. 0x1 0x0 " BIT_CNT                   ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " BYTE_CNT_RX               ,"
    textline "                   "
    hexmask.long.byte 0x0 16.--23. 0x1 0x0 " BYTE_CNT_TX               ,"
    textline "                   "
    hexmask.long.byte 0x0 24.--24. 0x1 0x0 " BUS_CONTENTION            ,"
    textline "                   "
    hexmask.long.byte 0x0 25.--25. 0x1 0x0 " TOO_LONG_SCL_STRETCH      ,"
    textline "                   "
    hexmask.long.byte 0x0 26.--26. 0x1 0x0 " SCL_IN                    ,"
    textline "                   "
    hexmask.long.byte 0x0 27.--27. 0x1 0x0 " SDA_IN                    ,"
    textline "                   "
    hexmask.long.byte 0x0 28.--28. 0x1 0x0 " FISRT_TO_ASSERT_SMBALERT  ,"
    textline "                   "
    hexmask.long.byte 0x0 29.--29. 0x1 0x0 " TOO_LONG_SCL_HIGH         ,"

; ------------------------- CNFG member of pmbus -------------------------

  group 0x0004++0x0003
    line.long 0x000 "CNFG, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " EN_PHY                    ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " DS_FSM_FSM_CLK_G          ,"
    textline "                   "
    hexmask.long.byte 0x0 2.--2. 0x1 0x0 " DS_FSM_IRQ_CLK_G          ,"
    textline "                   "
    hexmask.long.byte 0x0 3.--3. 0x1 0x0 " DS_APB_IRQ_CLK_G          ,"
    textline "                   "
    hexmask.long.byte 0x0 4.--4. 0x1 0x0 " PREEMPTIVE                ,"
    textline "                   "
    hexmask.long.byte 0x0 5.--5. 0x1 0x0 " EN_AUTO_TRANSMIT_TX_PEC   ,"
    textline "                   "
    hexmask.long.byte 0x0 6.--6. 0x1 0x0 " USE_START_IRQ_DELAY       ,"
    textline "                   "
    hexmask.long.byte 0x0 7.--9. 0x1 0x0 " DEBOUNCE_LENGTH           ,"
    textline "                   "
    hexmask.long.word 0x0 10.--18. 0x1 0x0 " WDT_SCL_STRETCH           ,"
    textline "                   "
    hexmask.long.word 0x0 19.--31. 0x1 0x0 " WDT_SCL_LOW_MAX           ,"

; ------------------------- ISR member of pmbus -------------------------

  group 0x0008++0x0003
    line.long 0x000 "ISR, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " I_FSM                     ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " IE_FSM                    ,"
    textline "                   "
    hexmask.long.byte 0x0 2.--2. 0x1 0x0 " SEL_FLAG_SRC              ,Select the flags source: 0 - Normal register 1 - FIFO IRQ"
    textline "                   "
    bitfld.long 0x0 3.--6. " I_CODE                    ," "NONE_IRQ (0),START_IRQ (1),RX_ADR_W_IRQ (2),RX_IRQ (3),RX_ADR_R_IRQ (4),TX_IRQ (5),STOP_IRQ (6),WDT_IRQ (7),BUSY_IRQ (8),%x..."

; ------------------------ ARA_CW member of pmbus ------------------------

  group 0x000C++0x0003
    line.long 0x000 "ARA_CW, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " EN_ARA_CW                 ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " DIRECTION                 ,"
    textline "                   "
    hexmask.long.byte 0x0 2.--8. 0x1 0x0 " ARA_ADDR                  ,"
    textline "                   "
    hexmask.long.byte 0x0 9.--9. 0x1 0x0 " SMBALERT                  ,"
    textline "                   "
    hexmask.long.byte 0x0 10.--16. 0x1 0x0 " SLAVE_ADDR_GEN_SMBALERT   ,"

; ----------------------- CTRL_RX member of pmbus -----------------------

  group 0x0010++0x0003
    line.long 0x000 "CTRL_RX, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " RX_TRIGGER                ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " ACK_RECEPTION             ,"
    textline "                   "
    bitfld.long 0x0 2.--4. " ACK_SRC_SEL               ," "NACK_0 (0),ADR_HIT (1),DATA_HIT (2),PEC_CHK (3),ACK (4),NACK_5 (5),NACK_6 (6),NACK_7 (7)"
    textline "                   "
    bitfld.long 0x0 5.--6. " DATA_LUT_OP               ," "DONT_CARE_0 (0),CLR (1),MSK (2),SET (3)"
    textline "                   "
    hexmask.long.byte 0x0 7.--7. 0x1 0x0 " RX_REQ                    ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " MIN_RANGE                 ,"
    textline "                   "
    hexmask.long.byte 0x0 16.--23. 0x1 0x0 " MAX_RANGE                 ,"

; ------------------------ RXDATA member of pmbus ------------------------

  rgroup 0x0014++0x0003
    line.long 0x000 "RXDATA, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,"

; ------------------------ RXPEC member of pmbus ------------------------

  rgroup 0x0018++0x0003
    line.long 0x000 "RXPEC, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,"

; ----------------------- CTRL_TX member of pmbus -----------------------

  group 0x0020++0x0003
    line.long 0x000 "CTRL_TX, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " TX_TRIGGER                ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " DROP_TRANSMISSION         ,"
    textline "                   "
    hexmask.long.word 0x0 2.--10. 0x1 0x0 " BYTE_TO_TX                ,"
    textline "                   "
    hexmask.long.byte 0x0 11.--13. 0x1 0x0 " BYTE_REMAINING            ,"
    textline "                   "
    bitfld.long 0x0 14.--15. " DATA_LUT_OP               ," "DONT_CARE_0 (0),CLR (1),MSK (2),SET (3)"
    textline "                   "
    hexmask.long.byte 0x0 16.--16. 0x1 0x0 " TX_REQ                    ,"

; ------------------------ TXDATA member of pmbus ------------------------

  rgroup 0x0024++0x0003
    line.long 0x000 "TXDATA, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,"

; ------------------------ TXPEC member of pmbus ------------------------

  rgroup 0x0028++0x0003
    line.long 0x000 "TXPEC, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,"

; ----------------------- DMA_CTRL member of pmbus -----------------------

  group 0x002C++0x0003
    line.long 0x000 "DMA_CTRL, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " EN_DMARX                  ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " EN_DMATX                  ,"

; ----------------------- ADDR_LUT member of pmbus -----------------------

  group 0x0040++0x0003
    line.long 0x000 "ADDR_LUT #0, "
    textline "                   "
    bitfld.long 0x0 0.--1. " EN_ADDR                   ," "DS (0),WR (1),RD (2),RW (3)"
    textline "                   "
    hexmask.long.byte 0x0 2.--8. 0x1 0x0 " ADDR                      ,"
    textline "                   "
    bitfld.long 0x0 9.--10. " TYPE                      ," "PMB (0),I2C (1),RES0 (2),RES1 (3)"

  group 0x0044++0x0003
    line.long 0x000 "ADDR_LUT #1, "
    textline "                   "
    bitfld.long 0x0 0.--1. " EN_ADDR                   ," "DS (0),WR (1),RD (2),RW (3)"
    textline "                   "
    hexmask.long.byte 0x0 2.--8. 0x1 0x0 " ADDR                      ,"
    textline "                   "
    bitfld.long 0x0 9.--10. " TYPE                      ," "PMB (0),I2C (1),RES0 (2),RES1 (3)"

  group 0x0048++0x0003
    line.long 0x000 "ADDR_LUT #2, "
    textline "                   "
    bitfld.long 0x0 0.--1. " EN_ADDR                   ," "DS (0),WR (1),RD (2),RW (3)"
    textline "                   "
    hexmask.long.byte 0x0 2.--8. 0x1 0x0 " ADDR                      ,"
    textline "                   "
    bitfld.long 0x0 9.--10. " TYPE                      ," "PMB (0),I2C (1),RES0 (2),RES1 (3)"

  group 0x004C++0x0003
    line.long 0x000 "ADDR_LUT #3, "
    textline "                   "
    bitfld.long 0x0 0.--1. " EN_ADDR                   ," "DS (0),WR (1),RD (2),RW (3)"
    textline "                   "
    hexmask.long.byte 0x0 2.--8. 0x1 0x0 " ADDR                      ,"
    textline "                   "
    bitfld.long 0x0 9.--10. " TYPE                      ," "PMB (0),I2C (1),RES0 (2),RES1 (3)"

  group 0x0050++0x0003
    line.long 0x000 "ADDR_LUT #4, "
    textline "                   "
    bitfld.long 0x0 0.--1. " EN_ADDR                   ," "DS (0),WR (1),RD (2),RW (3)"
    textline "                   "
    hexmask.long.byte 0x0 2.--8. 0x1 0x0 " ADDR                      ,"
    textline "                   "
    bitfld.long 0x0 9.--10. " TYPE                      ," "PMB (0),I2C (1),RES0 (2),RES1 (3)"

  group 0x0054++0x0003
    line.long 0x000 "ADDR_LUT #5, "
    textline "                   "
    bitfld.long 0x0 0.--1. " EN_ADDR                   ," "DS (0),WR (1),RD (2),RW (3)"
    textline "                   "
    hexmask.long.byte 0x0 2.--8. 0x1 0x0 " ADDR                      ,"
    textline "                   "
    bitfld.long 0x0 9.--10. " TYPE                      ," "PMB (0),I2C (1),RES0 (2),RES1 (3)"

  group 0x0058++0x0003
    line.long 0x000 "ADDR_LUT #6, "
    textline "                   "
    bitfld.long 0x0 0.--1. " EN_ADDR                   ," "DS (0),WR (1),RD (2),RW (3)"
    textline "                   "
    hexmask.long.byte 0x0 2.--8. 0x1 0x0 " ADDR                      ,"
    textline "                   "
    bitfld.long 0x0 9.--10. " TYPE                      ," "PMB (0),I2C (1),RES0 (2),RES1 (3)"

  group 0x005C++0x0003
    line.long 0x000 "ADDR_LUT #7, "
    textline "                   "
    bitfld.long 0x0 0.--1. " EN_ADDR                   ," "DS (0),WR (1),RD (2),RW (3)"
    textline "                   "
    hexmask.long.byte 0x0 2.--8. 0x1 0x0 " ADDR                      ,"
    textline "                   "
    bitfld.long 0x0 9.--10. " TYPE                      ," "PMB (0),I2C (1),RES0 (2),RES1 (3)"

; ----------------------- DATA_LUT member of pmbus -----------------------

  group 0x0080++0x0003
    line.long 0x000 "DATA_LUT #0, "
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " DATA                      ,"

  group 0x0084++0x0003
    line.long 0x000 "DATA_LUT #1, "
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " DATA                      ,"

  group 0x0088++0x0003
    line.long 0x000 "DATA_LUT #2, "
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " DATA                      ,"

  group 0x008C++0x0003
    line.long 0x000 "DATA_LUT #3, "
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " DATA                      ,"

  group 0x0090++0x0003
    line.long 0x000 "DATA_LUT #4, "
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " DATA                      ,"

  group 0x0094++0x0003
    line.long 0x000 "DATA_LUT #5, "
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " DATA                      ,"

  group 0x0098++0x0003
    line.long 0x000 "DATA_LUT #6, "
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " DATA                      ,"

  group 0x009C++0x0003
    line.long 0x000 "DATA_LUT #7, "
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " DATA                      ,"

; ------------------- DATA_LUT_BIT_SET member of pmbus -------------------

  group 0x00C0++0x0003
    line.long 0x000 "DATA_LUT_BIT_SET, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " INDEX                     ,"

; ------------------- DATA_LUT_BIT_CLR member of pmbus -------------------

  group 0x00C4++0x0003
    line.long 0x000 "DATA_LUT_BIT_CLR, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " INDEX                     ,"

; --------------------- STATUS_WORD member of pmbus ---------------------

  rgroup 0x0100++0x0003
    line.long 0x000 "STATUS_WORD #0, "
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " STATUS_WORD               ,"

  rgroup 0x0104++0x0003
    line.long 0x000 "STATUS_WORD #1, "
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " STATUS_WORD               ,"

; --------------------- STATUS_VOUT member of pmbus ---------------------

  group 0x0108++0x0003
    line.long 0x000 "STATUS_VOUT #0, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " STATUS_VOUT               ,"

  group 0x010C++0x0003
    line.long 0x000 "STATUS_VOUT #1, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " STATUS_VOUT               ,"

; --------------------- STATUS_IOUT member of pmbus ---------------------

  group 0x0110++0x0003
    line.long 0x000 "STATUS_IOUT #0, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " STATUS_IOUT               ,"

  group 0x0114++0x0003
    line.long 0x000 "STATUS_IOUT #1, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " STATUS_IOUT               ,"

; --------------------- STATUS_INPUT member of pmbus ---------------------

  group 0x0118++0x0003
    line.long 0x000 "STATUS_INPUT #0, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " STATUS_INPUT              ,"

  group 0x011C++0x0003
    line.long 0x000 "STATUS_INPUT #1, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " STATUS_INPUT              ,"

; --------------------- STATUS_TEMP member of pmbus ---------------------

  group 0x0120++0x0003
    line.long 0x000 "STATUS_TEMP #0, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " STATUS_TEMP               ,"

  group 0x0124++0x0003
    line.long 0x000 "STATUS_TEMP #1, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " STATUS_TEMP               ,"

; ---------------------- STATUS_CML member of pmbus ----------------------

  group 0x0128++0x0003
    line.long 0x000 "STATUS_CML #0, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " STATUS_CML                ,"

  group 0x012C++0x0003
    line.long 0x000 "STATUS_CML #1, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " STATUS_CML                ,"

; --------------------- STATUS_OTHER member of pmbus ---------------------

  group 0x0130++0x0003
    line.long 0x000 "STATUS_OTHER #0, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " STATUS_OTHER              ,"

  group 0x0134++0x0003
    line.long 0x000 "STATUS_OTHER #1, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " STATUS_OTHER              ,"

; ---------------------- STATUS_MFR member of pmbus ----------------------

  group 0x0138++0x0003
    line.long 0x000 "STATUS_MFR #0, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " STATUS_MFR                ,"

  group 0x013C++0x0003
    line.long 0x000 "STATUS_MFR #1, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " STATUS_MFR                ,"

; --------------------- STATUS_FAN12 member of pmbus ---------------------

  group 0x0140++0x0003
    line.long 0x000 "STATUS_FAN12 #0, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " STATUS_FAN12              ,"

  group 0x0144++0x0003
    line.long 0x000 "STATUS_FAN12 #1, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " STATUS_FAN12              ,"

; -------------------- STATUS_PWRGOOD member of pmbus --------------------

  group 0x0148++0x0003
    line.long 0x000 "STATUS_PWRGOOD #0, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " STATUS_PWRGOOD            ,"

  group 0x014C++0x0003
    line.long 0x000 "STATUS_PWRGOOD #1, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " STATUS_PWRGOOD            ,"

; ---------------------- STATUS_OFF member of pmbus ----------------------

  group 0x0150++0x0003
    line.long 0x000 "STATUS_OFF #0, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " STATUS_OFF                ,"

  group 0x0154++0x0003
    line.long 0x000 "STATUS_OFF #1, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " STATUS_OFF                ,"

; --------------------- STATUS_BUSY member of pmbus ---------------------

  group 0x0158++0x0003
    line.long 0x000 "STATUS_BUSY #0, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " STATUS_BUSY               ,"

  group 0x015C++0x0003
    line.long 0x000 "STATUS_BUSY #1, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " STATUS_BUSY               ,"

; -------------------- STATUS_UNKNOWN member of pmbus --------------------

  group 0x0160++0x0003
    line.long 0x000 "STATUS_UNKNOWN #0, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " STATUS_UNKNOWN            ,"

  group 0x0164++0x0003
    line.long 0x000 "STATUS_UNKNOWN #1, "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " STATUS_UNKNOWN            ,"

; ------------------- STATUS_CLEAR_ALL member of pmbus -------------------

  group 0x0168++0x0003
    line.long 0x000 "STATUS_CLEAR_ALL #0, Clears all status except PWRGOOD and OFF"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " STATUS_CLEAR_ALL          ,"

  group 0x016C++0x0003
    line.long 0x000 "STATUS_CLEAR_ALL #1, Clears all status except PWRGOOD and OFF"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " STATUS_CLEAR_ALL          ,"

; ------------------- STATUS_MASK_LP0 member of pmbus -------------------

  group 0x0170++0x0003
    line.long 0x000 "STATUS_MASK_LP0 #0, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " STATUS_VOUT_MASK          ,"

  group 0x0174++0x0003
    line.long 0x000 "STATUS_MASK_LP0 #1, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " STATUS_VOUT_MASK          ,"

  group 0x0178++0x0003
    line.long 0x000 "STATUS_MASK_LP0 #2, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " STATUS_VOUT_MASK          ,"

  group 0x017C++0x0003
    line.long 0x000 "STATUS_MASK_LP0 #3, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " STATUS_VOUT_MASK          ,"

  group 0x0180++0x0003
    line.long 0x000 "STATUS_MASK_LP0 #4, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " STATUS_VOUT_MASK          ,"

  group 0x0184++0x0003
    line.long 0x000 "STATUS_MASK_LP0 #5, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " STATUS_VOUT_MASK          ,"

  group 0x0188++0x0003
    line.long 0x000 "STATUS_MASK_LP0 #6, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " STATUS_VOUT_MASK          ,"

  group 0x018C++0x0003
    line.long 0x000 "STATUS_MASK_LP0 #7, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " STATUS_VOUT_MASK          ,"

; ------------------- STATUS_MASK_LP1 member of pmbus -------------------

  group 0x0190++0x0003
    line.long 0x000 "STATUS_MASK_LP1 #0, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " STATUS_IOUT_MASK          ,"

  group 0x0194++0x0003
    line.long 0x000 "STATUS_MASK_LP1 #1, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " STATUS_IOUT_MASK          ,"

  group 0x0198++0x0003
    line.long 0x000 "STATUS_MASK_LP1 #2, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " STATUS_IOUT_MASK          ,"

  group 0x019C++0x0003
    line.long 0x000 "STATUS_MASK_LP1 #3, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " STATUS_IOUT_MASK          ,"

  group 0x01A0++0x0003
    line.long 0x000 "STATUS_MASK_LP1 #4, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " STATUS_IOUT_MASK          ,"

  group 0x01A4++0x0003
    line.long 0x000 "STATUS_MASK_LP1 #5, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " STATUS_IOUT_MASK          ,"

  group 0x01A8++0x0003
    line.long 0x000 "STATUS_MASK_LP1 #6, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " STATUS_IOUT_MASK          ,"

  group 0x01AC++0x0003
    line.long 0x000 "STATUS_MASK_LP1 #7, "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " STATUS_IOUT_MASK          ,"

tree.end

; -------------------------------------------------------------------
; End Block - pmbus
; -------------------------------------------------------------------
tree.end
; @file:      pwm.per
; Chip name:  SHASTA
; Module:     pwm
; 
; Generated by the pmm metagen library.
;
; ===================================================================
; Copyright (C) 2018 Infineon Technologies AG
; All rights reserved.
; ===================================================================
;
; ===================================================================
; This document contains proprietary information. Passing on and
; copying of this document, and communication of its contents is not
; permitted without prior written authorisation.
; ===================================================================

; This file is automatically generated. Do not edit!


config 32. 8.
width 20.

tree "Block - pwm"
; -------------------------------------------------------------------
; Begin Block - pwm
; -------------------------------------------------------------------
base D:0x70002C00

tree "pwm"
; ---------------------- RAMP_CONFIG member of pwm ----------------------

  group 0x0000++0x0003
    line.long 0x000 "RAMP_CONFIG, PID select for Ramp 0 "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " ramp0_pid_sel             ,PID select for Ramp 0 "
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " ramp0_sync_sel            ,Sync select for Ramp 0 "
    textline "                   "
    hexmask.long.byte 0x0 2.--3. 0x1 0x0 " ramp0_m_flavor            ,Modulation type for Ramp 0 "
    textline "                   "
    hexmask.long.byte 0x0 4.--4. 0x1 0x0 " ramp0_half_mode           ,Half mode enable for Ramp 0.  When half mode is enabled, the ramp count is equal to half of tswitch, otherwise it is equal to tswitch.  Half mode should be enabled for the Full- and Half-Bridge topologies. "
    textline "                   "
    hexmask.long.byte 0x0 5.--5. 0x1 0x0 " ramp0_min_pw_state        ,Selects what to do when pulse width from PID duty cycle "
    textline "                   "
    hexmask.long.byte 0x0 6.--6. 0x1 0x0 " ramp1_pid_sel             ,PID select for Ramp 1 "
    textline "                   "
    hexmask.long.byte 0x0 7.--7. 0x1 0x0 " ramp1_sync_sel            ,Sync select for Ramp 1 "
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " ramp1_m_flavor            ,Modulation type for Ramp 1 "
    textline "                   "
    hexmask.long.byte 0x0 10.--10. 0x1 0x0 " ramp1_half_mode           ,Half mode enable for Ramp 1.  When half mode is enabled, the ramp count is equal to half of tswitch, otherwise it is equal to tswitch.  Half mode should be enabled for the Full- and Half-Bridge topologies. "
    textline "                   "
    hexmask.long.byte 0x0 11.--11. 0x1 0x0 " ramp1_min_pw_state        ,Selects what to do when pulse width from PID duty cycle "
    textline "                   "
    hexmask.long.byte 0x0 12.--13. 0x1 0x0 " mode_control_loop0        ,Loop 0 control mode select "
    textline "                   "
    hexmask.long.byte 0x0 14.--15. 0x1 0x0 " mode_control_loop1        ,Loop 1 control mode select "
    textline "                   "
    hexmask.long.byte 0x0 16.--16. 0x1 0x0 " ramp0_dutyc_lock          ,Ramp 0 duty cycle lock enable.  When enabled, the odd half cycle duty cycle is locked to the even half cycle duty cycle prior to applying any flux balance correction.  Duty cycle lock is required when using flux balancing but may also be used without flux balance. "
    textline "                   "
    hexmask.long.byte 0x0 17.--17. 0x1 0x0 " ramp1_dutyc_lock          ,Ramp 1 duty cycle lock enable.  When enabled, the odd half cycle duty cycle is locked to the even half cycle duty cycle prior to applying any flux balance correction.  Duty cycle lock is required when using flux balancing but may also be used without flux balance. "
    textline "                   "
    hexmask.long.byte 0x0 18.--19. 0x1 0x0 " compensation_slope        ,Peak current mode control compensation ramp slope "

; ----------------------- PWM_TOPO_1 member of pwm -----------------------

  group 0x0004++0x0003
    line.long 0x000 "PWM_TOPO_1, Topology driven PWM falling edge select "
    textline "                   "
    hexmask.long.byte 0x0 0.--2. 0x1 0x0 " pwm1_fall_sel             ,Topology driven PWM falling edge select "
    textline "                   "
    hexmask.long.byte 0x0 3.--6. 0x1 0x0 " pwm1_rise_sel             ,Topology driven PWM rising edge select "
    textline "                   "
    hexmask.long.byte 0x0 7.--9. 0x1 0x0 " pwm2_fall_sel             ,Topology driven PWM falling edge select "
    textline "                   "
    hexmask.long.byte 0x0 10.--13. 0x1 0x0 " pwm2_rise_sel             ,Topology driven PWM rising edge select "
    textline "                   "
    hexmask.long.byte 0x0 14.--16. 0x1 0x0 " pwm3_fall_sel             ,Topology driven PWM falling edge select "
    textline "                   "
    hexmask.long.byte 0x0 17.--20. 0x1 0x0 " pwm3_rise_sel             ,Topology driven PWM rising edge select "
    textline "                   "
    hexmask.long.byte 0x0 21.--23. 0x1 0x0 " pwm4_fall_sel             ,Topology driven PWM falling edge select "
    textline "                   "
    hexmask.long.byte 0x0 24.--27. 0x1 0x0 " pwm4_rise_sel             ,Topology driven PWM rising edge select "

; ----------------------- PWM_TOPO_2 member of pwm -----------------------

  group 0x0008++0x0003
    line.long 0x000 "PWM_TOPO_2, Topology driven PWM falling edge select "
    textline "                   "
    hexmask.long.byte 0x0 0.--2. 0x1 0x0 " pwm5_fall_sel             ,Topology driven PWM falling edge select "
    textline "                   "
    hexmask.long.byte 0x0 3.--6. 0x1 0x0 " pwm5_rise_sel             ,Topology driven PWM rising edge select "
    textline "                   "
    hexmask.long.byte 0x0 7.--9. 0x1 0x0 " pwm6_fall_sel             ,Topology driven PWM falling edge select "
    textline "                   "
    hexmask.long.byte 0x0 10.--13. 0x1 0x0 " pwm6_rise_sel             ,Topology driven PWM rising edge select "
    textline "                   "
    hexmask.long.byte 0x0 14.--16. 0x1 0x0 " pwm7_fall_sel             ,Topology driven PWM falling edge select "
    textline "                   "
    hexmask.long.byte 0x0 17.--20. 0x1 0x0 " pwm7_rise_sel             ,Topology driven PWM rising edge select "
    textline "                   "
    hexmask.long.byte 0x0 21.--23. 0x1 0x0 " pwm8_fall_sel             ,Topology driven PWM falling edge select "
    textline "                   "
    hexmask.long.byte 0x0 24.--27. 0x1 0x0 " pwm8_rise_sel             ,Topology driven PWM rising edge select "

; ----------------------- PWM_TOPO_3 member of pwm -----------------------

  group 0x000C++0x0003
    line.long 0x000 "PWM_TOPO_3, Topology driven PWM falling edge select "
    textline "                   "
    hexmask.long.byte 0x0 0.--2. 0x1 0x0 " pwm9_fall_sel             ,Topology driven PWM falling edge select "
    textline "                   "
    hexmask.long.byte 0x0 3.--6. 0x1 0x0 " pwm9_rise_sel             ,Topology driven PWM rising edge select "
    textline "                   "
    hexmask.long.byte 0x0 7.--9. 0x1 0x0 " pwm10_fall_sel            ,Topology driven PWM falling edge select "
    textline "                   "
    hexmask.long.byte 0x0 10.--13. 0x1 0x0 " pwm10_rise_sel            ,Topology driven PWM rising edge select "
    textline "                   "
    hexmask.long.byte 0x0 14.--16. 0x1 0x0 " pwm11_fall_sel            ,Topology driven PWM falling edge select "
    textline "                   "
    hexmask.long.byte 0x0 17.--20. 0x1 0x0 " pwm11_rise_sel            ,Topology driven PWM rising edge select "
    textline "                   "
    hexmask.long.byte 0x0 21.--23. 0x1 0x0 " pwm12_fall_sel            ,Topology driven PWM falling edge select "
    textline "                   "
    hexmask.long.byte 0x0 24.--27. 0x1 0x0 " pwm12_rise_sel            ,Topology driven PWM rising edge select "

; ------------------------ PWM_MAP member of pwm ------------------------

  group 0x0010++0x0003
    line.long 0x000 "PWM_MAP, PWM1 Loop, Phase mapping "
    textline "                   "
    hexmask.long.byte 0x0 0.--1. 0x1 0x0 " pwm1_loop_map             ,PWM1 Loop, Phase mapping "
    textline "                   "
    hexmask.long.byte 0x0 2.--3. 0x1 0x0 " pwm2_loop_map             ,PWM2 Loop, Phase mapping "
    textline "                   "
    hexmask.long.byte 0x0 4.--5. 0x1 0x0 " pwm3_loop_map             ,PWM3 Loop, Phase mapping "
    textline "                   "
    hexmask.long.byte 0x0 6.--7. 0x1 0x0 " pwm4_loop_map             ,PWM4 Loop, Phase mapping "
    textline "                   "
    hexmask.long.byte 0x0 8.--9. 0x1 0x0 " pwm5_loop_map             ,PWM5 Loop, Phase mapping "
    textline "                   "
    hexmask.long.byte 0x0 10.--11. 0x1 0x0 " pwm6_loop_map             ,PWM6 Loop, Phase mapping "
    textline "                   "
    hexmask.long.byte 0x0 12.--13. 0x1 0x0 " pwm7_loop_map             ,PWM7 Loop, Phase mapping "
    textline "                   "
    hexmask.long.byte 0x0 14.--15. 0x1 0x0 " pwm8_loop_map             ,PWM8 Loop, Phase mapping "
    textline "                   "
    hexmask.long.byte 0x0 16.--17. 0x1 0x0 " pwm9_loop_map             ,PWM9 Loop, Phase mapping "
    textline "                   "
    hexmask.long.byte 0x0 18.--19. 0x1 0x0 " pwm10_loop_map            ,PWM10 Loop, Phase mapping "
    textline "                   "
    hexmask.long.byte 0x0 20.--21. 0x1 0x0 " pwm11_loop_map            ,PWM11 Loop, Phase mapping "
    textline "                   "
    hexmask.long.byte 0x0 22.--23. 0x1 0x0 " pwm12_loop_map            ,PWM12 Loop, Phase mapping "

; --------------------- MAX_DUTY_SCALE member of pwm ---------------------

  group 0x0014++0x0003
    line.long 0x000 "MAX_DUTY_SCALE, PWM Ramp 0 nominal max duty cycle used for scaling with Vin. A setting of 0 disables max duty cycle scaling and ramp0_dc_max is used exclusively."
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " ramp0_dc_max_nom          ,PWM Ramp 0 nominal max duty cycle used for scaling with Vin. A setting of 0 disables max duty cycle scaling and ramp0_dc_max is used exclusively."
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " ramp1_dc_max_nom          ,PWM Ramp 1 nominal max duty cycle used for scaling with Vin. A setting of 0 disables max duty cycle scaling and ramp1_dc_max is used exclusively."

; ------------------------ PWM_FTR member of pwm ------------------------

  group 0x0018++0x0003
    line.long 0x000 "PWM_FTR, Loop 0 Fast Transient Response (FTR) input voltage threshold.  Below this threshold, the FTR pulsewidth is based on the feed forward duty cycle from the PID.  Above this threshold, the FTR pulse width is reduced in proportion to Vin. if (Vin < lp0_ftr_vin_thresh)     FTR PW = (Vout/Vrect) * (Tswitch/2) else     FTR PW = (Vout/Vrect) * (Tswitch/2) * (lp0_ftr_fin_thresh/Vin)"
    textline "                   "
    hexmask.long.byte 0x0 0.--6. 0x1 0x0 " lp0_ftr_vin_thresh        ,Loop 0 Fast Transient Response (FTR) input voltage threshold.  Below this threshold, the FTR pulsewidth is based on the feed forward duty cycle from the PID.  Above this threshold, the FTR pulse width is reduced in proportion to Vin. if (Vin < lp0_ftr_vin_thresh)     FTR PW = (Vout/Vrect) * (Tswitch/2) else     FTR PW = (Vout/Vrect) * (Tswitch/2) * (lp0_ftr_fin_thresh/Vin)"
    textline "                   "
    hexmask.long.byte 0x0 7.--13. 0x1 0x0 " lp1_ftr_vin_thresh        ,Loop 1 Fast Transient Response (FTR) input voltage threshold.  Below this threshold, the FTR pulsewidth is based on the feed forward duty cycle from the PID.  Above this threshold, the FTR pulse width is reduced in proportion to Vin. if (Vin < lp1_ftr_vin_thresh)     FTR PW = (Vout/Vrect) * (Tswitch/2) else     FTR PW = (Vout/Vrect) * (Tswitch/2) * (lp1_ftr_fin_thresh/Vin)"

; ---------------------- RAMP0_PHASE member of pwm ----------------------

  group 0x001C++0x0003
    line.long 0x000 "RAMP0_PHASE, Ramp 0 phase alignment with respect to sync signal selected with ramp0_sync_sel. Computed from PMBus as follows: "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " ramp0_phase               ,Ramp 0 phase alignment with respect to sync signal selected with ramp0_sync_sel. Computed from PMBus as follows: "

; ---------------------- RAMP1_PHASE member of pwm ----------------------

  group 0x0020++0x0003
    line.long 0x000 "RAMP1_PHASE, Ramp 1 phase alignment with respect to sync signal selected with ramp1_sync_sel. Computed from PMBus as follows: "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " ramp1_phase               ,Ramp 1 phase alignment with respect to sync signal selected with ramp1_sync_sel. Computed from PMBus as follows: "

; -------------------- PWM_FORCE_HI_LO member of pwm --------------------

  group 0x0024++0x0003
    line.long 0x000 "PWM_FORCE_HI_LO, Force PWM output high, [0] corresponds to PWM1, [11] corresponds to PWM12."
    textline "                   "
    hexmask.long.word 0x0 0.--11. 0x1 0x0 " pwm_force_hi              ,Force PWM output high, [0] corresponds to PWM1, [11] corresponds to PWM12."
    textline "                   "
    hexmask.long.word 0x0 12.--23. 0x1 0x0 " pwm_force_lo              ,Force PWM output low, [0] corresponds to PWM1, [11] corresponds to PWM12.  This register has higher priority than pwm_force_hi."

; ------------------------- PWM_ON member of pwm -------------------------

  group 0x0028++0x0003
    line.long 0x000 "PWM_ON, PWM channel enabled when bit position high, [0] corresponds to PWM1, [11] corresponds to PWM12.  Intended to be driven by FW only."
    textline "                   "
    hexmask.long.word 0x0 0.--11. 0x1 0x0 " pwm_on                    ,PWM channel enabled when bit position high, [0] corresponds to PWM1, [11] corresponds to PWM12.  Intended to be driven by FW only."

; --------------------- RAMP0_TSWITCH0 member of pwm ---------------------

  group 0x002C++0x0003
    line.long 0x000 "RAMP0_TSWITCH0, PWM Ramp 0 switching period.  This register defines the switching period of ramp 0 when ramp0_sync_sel is set to internal sync or when ramp0_sync_sel is set to external sync but and exteranl sync signal is not provided. Computed from PMBus as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--8. 0x1 0x0 " tswitch0                  ,PWM Ramp 0 switching period.  This register defines the switching period of ramp 0 when ramp0_sync_sel is set to internal sync or when ramp0_sync_sel is set to external sync but and exteranl sync signal is not provided. Computed from PMBus as follows: "

; -------------------- RAMP0_PW_MINMAX member of pwm --------------------

  group 0x0030++0x0003
    line.long 0x000 "RAMP0_PW_MINMAX, PWM Ramp 0 max duty cycle (absolute). Computed from PMBus as follows: "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " ramp0_dc_max              ,PWM Ramp 0 max duty cycle (absolute). Computed from PMBus as follows: "
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " ramp0_pw_min              ,PWM Ramp 0 min pulse width.  When the duty cycle from the PID is less than this value the duty cycle input to the ramp is either clamped to this value or set to 0 as determined by the setting of ramp0_pw_min_state. Computed from PMBus as follows: "

; -------------------- RAMP0_FORCE_DUTY member of pwm --------------------

  group 0x0034++0x0003
    line.long 0x000 "RAMP0_FORCE_DUTY, Forced duty cycle value overrides ramp 0 input when selected by ramp0_force_duty_en.  Since this force is applied at the ramp input, upstream adjustments to the duty cycle such as current balance in an interleaved (multi-phase) design are overwritten.  To not override the current balance adjust use pid0.pid_force_duty or pid1.pid_force_duty."
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " ramp0_force_duty          ,Forced duty cycle value overrides ramp 0 input when selected by ramp0_force_duty_en.  Since this force is applied at the ramp input, upstream adjustments to the duty cycle such as current balance in an interleaved (multi-phase) design are overwritten.  To not override the current balance adjust use pid0.pid_force_duty or pid1.pid_force_duty."
    textline "                   "
    hexmask.long.byte 0x0 8.--8. 0x1 0x0 " ramp0_force_duty_en       ,PWM Ramp 0 forced duty cycle select. "

; --------------------- RAMP0_FORCE_T1 member of pwm ---------------------

  group 0x0038++0x0003
    line.long 0x000 "RAMP0_FORCE_T1, PWM Ramp 0 forced T1 setting selected by ramp0_force_t1_en.  T1 is the time of the first PWM  edge  in a ramp cycle.  In a trailing edge modulation scheme T1 is fixed at 0.  In the leading and dual edge modulation schemes T1 is determined based on the duty cycle."
    textline "                   "
    hexmask.long.word 0x0 0.--10. 0x1 0x0 " ramp0_force_t1            ,PWM Ramp 0 forced T1 setting selected by ramp0_force_t1_en.  T1 is the time of the first PWM  edge  in a ramp cycle.  In a trailing edge modulation scheme T1 is fixed at 0.  In the leading and dual edge modulation schemes T1 is determined based on the duty cycle."
    textline "                   "
    hexmask.long.byte 0x0 11.--11. 0x1 0x0 " ramp0_force_t1_en         ,PWM Ramp 0 T1 force enable. "

; --------------------- RAMP0_FORCE_T2 member of pwm ---------------------

  group 0x003C++0x0003
    line.long 0x000 "RAMP0_FORCE_T2, PWM Ramp 0 forced T2 setting selected by ramp0_force_t2_en.  T2 is the time of the second PWM  edge  in a ramp cycle.  In a leading edge modulation scheme T1 is fixed at Tswitch (or Tswitch/2 in bridge topologies).  In the trailing and dual edge modulation schemes T2 is determined based on the duty cycle."
    textline "                   "
    hexmask.long.word 0x0 0.--10. 0x1 0x0 " ramp0_force_t2            ,PWM Ramp 0 forced T2 setting selected by ramp0_force_t2_en.  T2 is the time of the second PWM  edge  in a ramp cycle.  In a leading edge modulation scheme T1 is fixed at Tswitch (or Tswitch/2 in bridge topologies).  In the trailing and dual edge modulation schemes T2 is determined based on the duty cycle."
    textline "                   "
    hexmask.long.byte 0x0 11.--11. 0x1 0x0 " ramp0_force_t2_en         ,PWM Ramp 0 T2 force enable. "

; --------------------- RAMP1_TSWITCH1 member of pwm ---------------------

  group 0x0040++0x0003
    line.long 0x000 "RAMP1_TSWITCH1, PWM Ramp 1 switching period.  This register defines the switching period of ramp 1 when ramp1_sync_sel is set to internal sync or when ramp1_sync_sel is set to external sync but and exteranl sync signal is not provided. Computed from PMBus as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--8. 0x1 0x0 " tswitch1                  ,PWM Ramp 1 switching period.  This register defines the switching period of ramp 1 when ramp1_sync_sel is set to internal sync or when ramp1_sync_sel is set to external sync but and exteranl sync signal is not provided. Computed from PMBus as follows: "

; -------------------- RAMP1_PW_MINMAX member of pwm --------------------

  group 0x0044++0x0003
    line.long 0x000 "RAMP1_PW_MINMAX, PWM Ramp 1 max duty cycle (absolute). Computed from PMBus as follows: "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " ramp1_dc_max              ,PWM Ramp 1 max duty cycle (absolute). Computed from PMBus as follows: "
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " ramp1_pw_min              ,PWM Ramp 1 min pulse width.  When the duty cycle from the PID is less than this value the duty cycle input to the ramp is either clamped to this value or set to 0 as determined by the setting of ramp1_pw_min_state. Computed from PMBus as follows: "

; -------------------- RAMP1_FORCE_DUTY member of pwm --------------------

  group 0x0048++0x0003
    line.long 0x000 "RAMP1_FORCE_DUTY, Forced duty cycle value overrides ramp 1 input when selected by ramp1_force_duty_en.  Since this force is applied at the ramp input, upstream adjustments to the duty cycle such as current balance in an interleaved (multi-phase) design are overwritten.  To not override the current balance adjust use pid0.pid_force_duty or pid1.pid_force_duty."
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " ramp1_force_duty          ,Forced duty cycle value overrides ramp 1 input when selected by ramp1_force_duty_en.  Since this force is applied at the ramp input, upstream adjustments to the duty cycle such as current balance in an interleaved (multi-phase) design are overwritten.  To not override the current balance adjust use pid0.pid_force_duty or pid1.pid_force_duty."
    textline "                   "
    hexmask.long.byte 0x0 8.--8. 0x1 0x0 " ramp1_force_duty_en       ,PWM Ramp 1 forced duty cycle select. "

; --------------------- RAMP1_FORCE_T1 member of pwm ---------------------

  group 0x004C++0x0003
    line.long 0x000 "RAMP1_FORCE_T1, PWM Ramp 1 forced T1 setting selected by ramp1_force_t1_en.  T1 is the time of the first PWM  edge  in a ramp cycle.  In a trailing edge modulation scheme T1 is fixed at 0.  In the leading and dual edge modulation schemes T1 is determined based on the duty cycle."
    textline "                   "
    hexmask.long.word 0x0 0.--10. 0x1 0x0 " ramp1_force_t1            ,PWM Ramp 1 forced T1 setting selected by ramp1_force_t1_en.  T1 is the time of the first PWM  edge  in a ramp cycle.  In a trailing edge modulation scheme T1 is fixed at 0.  In the leading and dual edge modulation schemes T1 is determined based on the duty cycle."
    textline "                   "
    hexmask.long.byte 0x0 11.--11. 0x1 0x0 " ramp1_force_t1_en         ,PWM Ramp 1 T1 force enable. "

; --------------------- RAMP1_FORCE_T2 member of pwm ---------------------

  group 0x0050++0x0003
    line.long 0x000 "RAMP1_FORCE_T2, PWM Ramp 1 forced T2 setting selected by ramp1_force_t2_en.  T2 is the time of the second PWM  edge  in a ramp cycle.  In a leading edge modulation scheme T1 is fixed at Tswitch (or Tswitch/2 in bridge topologies).  In the trailing and dual edge modulation schemes T2 is determined based on the duty cycle."
    textline "                   "
    hexmask.long.word 0x0 0.--10. 0x1 0x0 " ramp1_force_t2            ,PWM Ramp 1 forced T2 setting selected by ramp1_force_t2_en.  T2 is the time of the second PWM  edge  in a ramp cycle.  In a leading edge modulation scheme T1 is fixed at Tswitch (or Tswitch/2 in bridge topologies).  In the trailing and dual edge modulation schemes T2 is determined based on the duty cycle."
    textline "                   "
    hexmask.long.byte 0x0 11.--11. 0x1 0x0 " ramp1_force_t2_en         ,PWM Ramp 1 T2 force enable. "

; --------------------- PWM1_DEADTIME member of pwm ---------------------

  group 0x0054++0x0003
    line.long 0x000 "PWM1_DEADTIME, PWM1 rising edge delay (dead) time from T1 or T2.  Mapping of the rising edge to T1 or T2 defined by pwm1_rise_sel."
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " pwm1_dr                   ,PWM1 rising edge delay (dead) time from T1 or T2.  Mapping of the rising edge to T1 or T2 defined by pwm1_rise_sel."
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " pwm1_df                   ,PWM1 falling edge delay (dead) time from T1 or T2.  Mapping of the falling edge to T1 or T2 defined by pwm1_fall_sel."

; --------------------- PWM2_DEADTIME member of pwm ---------------------

  group 0x0058++0x0003
    line.long 0x000 "PWM2_DEADTIME, PWM2 rising edge delay (dead) time from T1 or T2.  Mapping of the rising edge to T1 or T2 defined by pwm2_rise_sel."
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " pwm2_dr                   ,PWM2 rising edge delay (dead) time from T1 or T2.  Mapping of the rising edge to T1 or T2 defined by pwm2_rise_sel."
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " pwm2_df                   ,PWM2 falling edge delay (dead) time from T1 or T2.  Mapping of the falling edge to T1 or T2 defined by pwm2_fall_sel."

; --------------------- PWM3_DEADTIME member of pwm ---------------------

  group 0x005C++0x0003
    line.long 0x000 "PWM3_DEADTIME, PWM3 rising edge delay (dead) time from T1 or T2.  Mapping of the rising edge to T1 or T2 defined by pwm3_rise_sel."
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " pwm3_dr                   ,PWM3 rising edge delay (dead) time from T1 or T2.  Mapping of the rising edge to T1 or T2 defined by pwm3_rise_sel."
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " pwm3_df                   ,PWM3 falling edge delay (dead) time from T1 or T2.  Mapping of the falling edge to T1 or T2 defined by pwm3_fall_sel."

; --------------------- PWM4_DEADTIME member of pwm ---------------------

  group 0x0060++0x0003
    line.long 0x000 "PWM4_DEADTIME, PWM4 rising edge delay (dead) time from T1 or T2.  Mapping of the rising edge to T1 or T2 defined by pwm4_rise_sel."
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " pwm4_dr                   ,PWM4 rising edge delay (dead) time from T1 or T2.  Mapping of the rising edge to T1 or T2 defined by pwm4_rise_sel."
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " pwm4_df                   ,PWM4 falling edge delay (dead) time from T1 or T2.  Mapping of the falling edge to T1 or T2 defined by pwm4_fall_sel."

; --------------------- PWM5_DEADTIME member of pwm ---------------------

  group 0x0064++0x0003
    line.long 0x000 "PWM5_DEADTIME, PWM5 rising edge delay (dead) time from T1 or T2.  Mapping of the rising edge to T1 or T2 defined by pwm5_rise_sel."
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " pwm5_dr                   ,PWM5 rising edge delay (dead) time from T1 or T2.  Mapping of the rising edge to T1 or T2 defined by pwm5_rise_sel."
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " pwm5_df                   ,PWM5 falling edge delay (dead) time from T1 or T2.  Mapping of the falling edge to T1 or T2 defined by pwm5_fall_sel."

; --------------------- PWM6_DEADTIME member of pwm ---------------------

  group 0x0068++0x0003
    line.long 0x000 "PWM6_DEADTIME, PWM6 rising edge delay (dead) time from T1 or T2.  Mapping of the rising edge to T1 or T2 defined by pwm6_rise_sel."
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " pwm6_dr                   ,PWM6 rising edge delay (dead) time from T1 or T2.  Mapping of the rising edge to T1 or T2 defined by pwm6_rise_sel."
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " pwm6_df                   ,PWM6 falling edge delay (dead) time from T1 or T2.  Mapping of the falling edge to T1 or T2 defined by pwm6_fall_sel."

; --------------------- PWM7_DEADTIME member of pwm ---------------------

  group 0x006C++0x0003
    line.long 0x000 "PWM7_DEADTIME, PWM7 rising edge delay (dead) time from T1 or T2.  Mapping of the rising edge to T1 or T2 defined by pwm7_rise_sel."
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " pwm7_dr                   ,PWM7 rising edge delay (dead) time from T1 or T2.  Mapping of the rising edge to T1 or T2 defined by pwm7_rise_sel."
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " pwm7_df                   ,PWM7 falling edge delay (dead) time from T1 or T2.  Mapping of the falling edge to T1 or T2 defined by pwm7_fall_sel."

; --------------------- PWM8_DEADTIME member of pwm ---------------------

  group 0x0070++0x0003
    line.long 0x000 "PWM8_DEADTIME, PWM8 rising edge delay (dead) time from T1 or T2.  Mapping of the rising edge to T1 or T2 defined by pwm8_rise_sel."
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " pwm8_dr                   ,PWM8 rising edge delay (dead) time from T1 or T2.  Mapping of the rising edge to T1 or T2 defined by pwm8_rise_sel."
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " pwm8_df                   ,PWM8 falling edge delay (dead) time from T1 or T2.  Mapping of the falling edge to T1 or T2 defined by pwm8_fall_sel."

; --------------------- PWM9_DEADTIME member of pwm ---------------------

  group 0x0074++0x0003
    line.long 0x000 "PWM9_DEADTIME, PWM9 rising edge delay (dead) time from T1 or T2.  Mapping of the rising edge to T1 or T2 defined by pwm9_rise_sel."
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " pwm9_dr                   ,PWM9 rising edge delay (dead) time from T1 or T2.  Mapping of the rising edge to T1 or T2 defined by pwm9_rise_sel."
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " pwm9_df                   ,PWM9 falling edge delay (dead) time from T1 or T2.  Mapping of the falling edge to T1 or T2 defined by pwm9_fall_sel."

; --------------------- PWM10_DEADTIME member of pwm ---------------------

  group 0x0078++0x0003
    line.long 0x000 "PWM10_DEADTIME, PWM10 rising edge delay (dead) time from T1 or T2.  Mapping of the rising edge to T1 or T2 defined by pwm10_rise_sel."
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " pwm10_dr                  ,PWM10 rising edge delay (dead) time from T1 or T2.  Mapping of the rising edge to T1 or T2 defined by pwm10_rise_sel."
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " pwm10_df                  ,PWM10 falling edge delay (dead) time from T1 or T2.  Mapping of the falling edge to T1 or T2 defined by pwm10_fall_sel."

; --------------------- PWM11_DEADTIME member of pwm ---------------------

  group 0x007C++0x0003
    line.long 0x000 "PWM11_DEADTIME, PWM11 rising edge delay (dead) time from T1 or T2.  Mapping of the rising edge to T1 or T2 defined by pwm11_rise_sel."
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " pwm11_dr                  ,PWM11 rising edge delay (dead) time from T1 or T2.  Mapping of the rising edge to T1 or T2 defined by pwm11_rise_sel."
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " pwm11_df                  ,PWM11 falling edge delay (dead) time from T1 or T2.  Mapping of the falling edge to T1 or T2 defined by pwm11_fall_sel."

; --------------------- PWM12_DEADTIME member of pwm ---------------------

  group 0x0080++0x0003
    line.long 0x000 "PWM12_DEADTIME, PWM12 rising edge delay (dead) time from T1 or T2.  Mapping of the rising edge to T1 or T2 defined by pwm12_rise_sel."
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " pwm12_dr                  ,PWM12 rising edge delay (dead) time from T1 or T2.  Mapping of the rising edge to T1 or T2 defined by pwm12_rise_sel."
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " pwm12_df                  ,PWM12 falling edge delay (dead) time from T1 or T2.  Mapping of the falling edge to T1 or T2 defined by pwm12_fall_sel."

; ---------------------- PWM_DUTYC_RD member of pwm ----------------------

  rgroup 0x0084++0x0003
    line.long 0x000 "PWM_DUTYC_RD, This register bit is set when a new duty cycle force has been applied on ramp 0. It is cleared when either ramp0_force_duty_en or ramp0_force_duty changes."
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " ramp0_dutyc_force_status  ,This register bit is set when a new duty cycle force has been applied on ramp 0. It is cleared when either ramp0_force_duty_en or ramp0_force_duty changes."
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " ramp1_dutyc_force_status  ,This register bit is set when a new duty cycle force has been applied on ramp 1. It is cleared when either ramp1_force_duty_en or ramp1_force_duty changes."

; ------------------------ CAL_DONE member of pwm ------------------------

  rgroup 0x0088++0x0003
    line.long 0x000 "CAL_DONE, This register bit is set when the initial current sense calibration is complete.  Current sense calibration is performed continuously after the first output enable after a VDD power up."
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " cal_all_done              ,This register bit is set when the initial current sense calibration is complete.  Current sense calibration is performed continuously after the first output enable after a VDD power up."

; ------------------------ RAMP_IRQ member of pwm ------------------------

  group 0x008C++0x0003
    line.long 0x000 "RAMP_IRQ, PWM Ramp 0 T1 Interrupt (IRQ) select. "
    textline "                   "
    hexmask.long.byte 0x0 0.--2. 0x1 0x0 " ramp0_t1_irq_sel          ,PWM Ramp 0 T1 Interrupt (IRQ) select. "
    textline "                   "
    hexmask.long.byte 0x0 3.--5. 0x1 0x0 " ramp0_t2_irq_sel          ,PWM Ramp 0 T2 Interrupt (IRQ) select. "
    textline "                   "
    hexmask.long.byte 0x0 6.--9. 0x1 0x0 " ramp0_irq_phase           ,Defines interrupt phase with respect to the internal PWM ramp phase when ramp0_t1__irq_sel=7. "
    textline "                   "
    hexmask.long.byte 0x0 10.--12. 0x1 0x0 " ramp0_irq_rate            ,Defines frequency of interrupts selected by ramp0_t1(2)_irq_sel.  0  every Tswitch  4  every 16 Tswitch  1  every 2 Tswitch  5  every 32 Tswitch  2  every 4 Tswitch  6  every 64 Tswitch  3  every 8 Tswitch  7  every 64 Tswitch "
    textline "                   "
    hexmask.long.byte 0x0 13.--15. 0x1 0x0 " ramp1_t1_irq_sel          ,PWM Ramp 1 T1 Interrupt (IRQ) select. "
    textline "                   "
    hexmask.long.byte 0x0 16.--18. 0x1 0x0 " ramp1_t2_irq_sel          ,PWM Ramp 1 T2 Interrupt (IRQ) select. "
    textline "                   "
    hexmask.long.byte 0x0 19.--22. 0x1 0x0 " ramp1_irq_phase           ,Defines interrupt phase with respect to the internal PWM ramp phase when ramp1_t1__irq_sel=7. "
    textline "                   "
    hexmask.long.byte 0x0 23.--25. 0x1 0x0 " ramp1_irq_rate            ,Defines frequency of interrupts selected by ramp1_t1(2)_irq_sel.  0  every Tswitch  4  every 16 Tswitch  1  every 2 Tswitch  5  every 32 Tswitch  2  every 4 Tswitch  6  every 64 Tswitch  3  every 8 Tswitch  7  every 64 Tswitch "
    textline "                   "
    hexmask.long.byte 0x0 26.--26. 0x1 0x0 " cal_all_done_irq_en       ,Enabled current sense calibration complete IRQ to CPU. "

; ---------------------- PWM_IN_MASK member of pwm ----------------------

  group 0x0090++0x0003
    line.long 0x000 "PWM_IN_MASK, When bit X is low, enables input buffer on PWM[X+1] input pin.  The input buffer can then be used for polling the state of the PWM output via the io_inputs status register.  Setting low also asserts interrupt PWM_IN_IRQ when the enabled PWM inputs are high."
    textline "                   "
    hexmask.long.word 0x0 0.--11. 0x1 0x0 " pwm_in_en_mask            ,When bit X is low, enables input buffer on PWM[X+1] input pin.  The input buffer can then be used for polling the state of the PWM output via the io_inputs status register.  Setting low also asserts interrupt PWM_IN_IRQ when the enabled PWM inputs are high."

tree.end

; -------------------------------------------------------------------
; End Block - pwm
; -------------------------------------------------------------------
tree.end
; @file:      rgu.per
; Chip name:  SHASTA
; Module:     rgu
; 
; Generated by the pmm metagen library.
;
; ===================================================================
; Copyright (C) 2018 Infineon Technologies AG
; All rights reserved.
; ===================================================================
;
; ===================================================================
; This document contains proprietary information. Passing on and
; copying of this document, and communication of its contents is not
; permitted without prior written authorisation.
; ===================================================================

; This file is automatically generated. Do not edit!


config 32. 8.
width 20.

tree "Block - rgu"
; -------------------------------------------------------------------
; Begin Block - rgu
; -------------------------------------------------------------------
base D:0x40001000

tree "rgu"
; ------------------------- RSTSR member of rgu -------------------------

  rgroup 0x0000++0x0003
    line.long 0x000 "RSTSR, Reset Status Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " SWPWDNRST                 ,1: The last reset has been generated by SW_PWDN signal"
    textline "                   "
    hexmask.long.byte 0x0 7.--7. 0x1 0x0 " HWPWDNRST                 ,1: The last reset has been generated by HW_PWDN signal"
    textline "                   "
    hexmask.long.byte 0x0 15.--15. 0x1 0x0 " SYSRST                    ,1: The last reset has been generated by SYSRESETQ signal"
    textline "                   "
    hexmask.long.byte 0x0 23.--23. 0x1 0x0 " SWRST                     ,1: The last reset was an SoftReset."
    textline "                   "
    hexmask.long.byte 0x0 31.--31. 0x1 0x0 " WDTRST                    ,1: The last reset was an Watchdog Reset."

; ----------------------- SWRST_CTRL member of rgu -----------------------

  group 0x0004++0x0003
    line.long 0x000 "SWRST_CTRL, Software Reset Control Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " EN_SWRST                  ,1: CPUS can be reset by SWRST bit."

; ------------------------ RSTMODS member of rgu ------------------------

  group 0x0008++0x0003
    line.long 0x000 "RSTMODS, Reset Modules Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " SWRST                     ,1: Enable Software Reset (CPU Subsystem reset enable)."
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " DMARST                    ,1: Performs a reset of the DMA."
    textline "                   "
    hexmask.long.byte 0x0 2.--2. 0x1 0x0 " CNFGOTP1WRST              ,1: Performs a reset of the OTP1 Wrapper."
    textline "                   "
    hexmask.long.byte 0x0 4.--4. 0x1 0x0 " BIFREGRST                 ,1: BIFREG Reset Signal set to 1."
    textline "                   "
    hexmask.long.byte 0x0 5.--5. 0x1 0x0 " BIFPERSVIDRST             ,1: Performs a reset of the BIF SVID IF."
    textline "                   "
    hexmask.long.byte 0x0 6.--6. 0x1 0x0 " BIFPERPMBUSRST            ,1: Performs a reset of the BIF PMBUS IF."
    textline "                   "
    hexmask.long.byte 0x0 7.--7. 0x1 0x0 " BIFPERSSPRST              ,1: Performs a reset of the BIF SSP IF."
    textline "                   "
    hexmask.long.byte 0x0 8.--8. 0x1 0x0 " BIFPERI2CRST              ,1: Performs a reset of the BIF I2C IF."
    textline "                   "
    hexmask.long.byte 0x0 9.--9. 0x1 0x0 " BIFPERUARTRST             ,1: Performs a reset of the BIF UART IF."
    textline "                   "
    hexmask.long.byte 0x0 11.--11. 0x1 0x0 " DTIMER1RST                ,1: Performs a reset of the DTIMER block."
    textline "                   "
    hexmask.long.byte 0x0 12.--12. 0x1 0x0 " DTIMER2RST                ,1: Performs a reset of the DTIMER2 block."
    textline "                   "
    hexmask.long.byte 0x0 13.--13. 0x1 0x0 " DTIMER3RST                ,1: Performs a reset of the DTIMER2 block."
    textline "                   "
    hexmask.long.byte 0x0 14.--14. 0x1 0x0 " WDTIFRST                  ,1: Performs a reset of the WDT IF block."
    textline "                   "
    hexmask.long.byte 0x0 15.--15. 0x1 0x0 " GPIO0RST                  ,1: Performs a reset of the GPIO0 block."
    textline "                   "
    hexmask.long.byte 0x0 16.--16. 0x1 0x0 " GPIO1RST                  ,1: Performs a reset of the GPIO1 block."

; ---------------------- SW_PWDN_REQ member of rgu ----------------------

  group 0x000C++0x0003
    line.long 0x000 "SW_PWDN_REQ, Software Power Down Request Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " SOFT_PWDN                 ,1: Request CPUS to enter in PowerDown. This will be effective    if the EN_SWPWDN bit has been set"

; ---------------------- SW_PWDN_CTRL member of rgu ----------------------

  group 0x0010++0x0003
    line.long 0x000 "SW_PWDN_CTRL, Software Power Down Control Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " EN_SWPWDN                 ,1: CPUS can be powered down by using SW procedure"

; ---------------------- HW_PWDN_CTRL member of rgu ----------------------

  group 0x0014++0x0003
    line.long 0x000 "HW_PWDN_CTRL, Hardware Power Down Control Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " EN_HWPWDN                 ,1: RAM/ROM can be powered down by using CPUS_EN signal"

; ------------------------ SPARE_FF member of rgu ------------------------

  group 0x0018++0x0003
    line.long 0x000 "SPARE_FF, Spare Register"
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " SPARE_FF                  ,Spare Register"

; ---------------------- RSTMODS_SET member of rgu ----------------------

  group 0x0020++0x0003
    line.long 0x000 "RSTMODS_SET, Reset Modules Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " SWRST                     ,1: Enable Software Reset (CPU Subsystem reset enable)."
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " DMARST                    ,1: Performs a reset of the DMA."
    textline "                   "
    hexmask.long.byte 0x0 2.--2. 0x1 0x0 " CNFGOTP1WRST              ,1: Performs a reset of the OTP1 Wrapper."
    textline "                   "
    hexmask.long.byte 0x0 4.--4. 0x1 0x0 " BIFREGRST                 ,1: BIFREG Reset Signal set to 1."
    textline "                   "
    hexmask.long.byte 0x0 5.--5. 0x1 0x0 " BIFPERSVIDRST             ,1: Performs a reset of the BIF SVID IF."
    textline "                   "
    hexmask.long.byte 0x0 6.--6. 0x1 0x0 " BIFPERPMBUSRST            ,1: Performs a reset of the BIF PMBUS IF."
    textline "                   "
    hexmask.long.byte 0x0 7.--7. 0x1 0x0 " BIFPERSSPRST              ,1: Performs a reset of the BIF SSP IF."
    textline "                   "
    hexmask.long.byte 0x0 8.--8. 0x1 0x0 " BIFPERI2CRST              ,1: Performs a reset of the BIF I2C IF."
    textline "                   "
    hexmask.long.byte 0x0 9.--9. 0x1 0x0 " BIFPERUARTRST             ,1: Performs a reset of the BIF UART IF."
    textline "                   "
    hexmask.long.byte 0x0 11.--11. 0x1 0x0 " DTIMER1RST                ,1: Performs a reset of the DTIMER block."
    textline "                   "
    hexmask.long.byte 0x0 12.--12. 0x1 0x0 " DTIMER2RST                ,1: Performs a reset of the DTIMER2 block."
    textline "                   "
    hexmask.long.byte 0x0 13.--13. 0x1 0x0 " DTIMER3RST                ,1: Performs a reset of the DTIMER2 block."
    textline "                   "
    hexmask.long.byte 0x0 14.--14. 0x1 0x0 " WDTIFRST                  ,1: Performs a reset of the WDT IF block."
    textline "                   "
    hexmask.long.byte 0x0 15.--15. 0x1 0x0 " GPIO0RST                  ,1: Performs a reset of the GPIO0 block."
    textline "                   "
    hexmask.long.byte 0x0 16.--16. 0x1 0x0 " GPIO1RST                  ,1: Performs a reset of the GPIO1 block."

; ---------------------- RSTMODS_CLR member of rgu ----------------------

  group 0x0024++0x0003
    line.long 0x000 "RSTMODS_CLR, Reset Modules Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " SWRST                     ,1: Enable Software Reset (CPU Subsystem reset enable)."
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " DMARST                    ,1: Performs a reset of the DMA."
    textline "                   "
    hexmask.long.byte 0x0 2.--2. 0x1 0x0 " CNFGOTP1WRST              ,1: Performs a reset of the OTP1 Wrapper."
    textline "                   "
    hexmask.long.byte 0x0 4.--4. 0x1 0x0 " BIFREGRST                 ,1: BIFREG Reset Signal set to 1."
    textline "                   "
    hexmask.long.byte 0x0 5.--5. 0x1 0x0 " BIFPERSVIDRST             ,1: Performs a reset of the BIF SVID IF."
    textline "                   "
    hexmask.long.byte 0x0 6.--6. 0x1 0x0 " BIFPERPMBUSRST            ,1: Performs a reset of the BIF PMBUS IF."
    textline "                   "
    hexmask.long.byte 0x0 7.--7. 0x1 0x0 " BIFPERSSPRST              ,1: Performs a reset of the BIF SSP IF."
    textline "                   "
    hexmask.long.byte 0x0 8.--8. 0x1 0x0 " BIFPERI2CRST              ,1: Performs a reset of the BIF I2C IF."
    textline "                   "
    hexmask.long.byte 0x0 9.--9. 0x1 0x0 " BIFPERUARTRST             ,1: Performs a reset of the BIF UART IF."
    textline "                   "
    hexmask.long.byte 0x0 11.--11. 0x1 0x0 " DTIMER1RST                ,1: Performs a reset of the DTIMER block."
    textline "                   "
    hexmask.long.byte 0x0 12.--12. 0x1 0x0 " DTIMER2RST                ,1: Performs a reset of the DTIMER2 block."
    textline "                   "
    hexmask.long.byte 0x0 13.--13. 0x1 0x0 " DTIMER3RST                ,1: Performs a reset of the DTIMER2 block."
    textline "                   "
    hexmask.long.byte 0x0 14.--14. 0x1 0x0 " WDTIFRST                  ,1: Performs a reset of the WDT IF block."
    textline "                   "
    hexmask.long.byte 0x0 15.--15. 0x1 0x0 " GPIO0RST                  ,1: Performs a reset of the GPIO0 block."
    textline "                   "
    hexmask.long.byte 0x0 16.--16. 0x1 0x0 " GPIO1RST                  ,1: Performs a reset of the GPIO1 block."

tree.end

; -------------------------------------------------------------------
; End Block - rgu
; -------------------------------------------------------------------
tree.end
; @file:      scu.per
; Chip name:  SHASTA
; Module:     scu
; 
; Generated by the pmm metagen library.
;
; ===================================================================
; Copyright (C) 2018 Infineon Technologies AG
; All rights reserved.
; ===================================================================
;
; ===================================================================
; This document contains proprietary information. Passing on and
; copying of this document, and communication of its contents is not
; permitted without prior written authorisation.
; ===================================================================

; This file is automatically generated. Do not edit!


config 32. 8.
width 20.

tree "Block - scu"
; -------------------------------------------------------------------
; Begin Block - scu
; -------------------------------------------------------------------
base D:0x40000000

tree "scu"
; ------------------------ CPUS_CFG member of scu ------------------------

  group 0x0000++0x0003
    line.long 0x000 "CPUS_CFG, CPU Subsystem Configuration Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " SET_REMAP                 ,1: Remap signal set to 1"
    textline "                   "
    hexmask.long.byte 0x0 2.--2. 0x1 0x0 " DS_DBGPORT                ,1: DBG Port connection is disabled"
    textline "                   "
    hexmask.long.byte 0x0 3.--3. 0x1 0x0 " EN_EXTWKUP                ,1: CPUS Ext wakeup is enabled"
    textline "                   "
    hexmask.long.byte 0x0 4.--4. 0x1 0x0 " USR_CNFG0                 ,1: USR_CNFG0 signal set to High"
    textline "                   "
    hexmask.long.byte 0x0 5.--5. 0x1 0x0 " USR_CNFG1                 ,1: USR_CNFG1 signal set to High"
    textline "                   "
    hexmask.long.byte 0x0 6.--6. 0x1 0x0 " USR_CNFG2                 ,1: USR_CNFG2 signal set to High"
    textline "                   "
    hexmask.long.byte 0x0 7.--7. 0x1 0x0 " USR_CNFG3                 ,1: USR_CNFG3 signal set to High"
    textline "                   "
    hexmask.long.byte 0x0 8.--8. 0x1 0x0 " USR_CNFG4                 ,1: USR_CNFG4 signal set to High"
    textline "                   "
    hexmask.long.byte 0x0 9.--9. 0x1 0x0 " USR_CNFG5                 ,1: USR_CNFG5 signal set to High"
    textline "                   "
    hexmask.long.byte 0x0 10.--10. 0x1 0x0 " USR_CNFG6                 ,1: USR_CNFG6 signal set to High"
    textline "                   "
    hexmask.long.byte 0x0 11.--11. 0x1 0x0 " OTP_KEEP_PWR_ST           ,1: OTP keep power state after a reset"
    textline "                   "
    hexmask.long.byte 0x0 12.--12. 0x1 0x0 " SEL_SRC_DTIMER32_KRN_CLK  ,1: USR_CNFG7 signal set to High"
    textline "                   "
    hexmask.long.byte 0x0 13.--13. 0x1 0x0 " SEL_SRC_DTIMER31_KRN_CLK  ,1: USR_CNFG7 signal set to High"
    textline "                   "
    hexmask.long.byte 0x0 14.--14. 0x1 0x0 " SEL_SRC_DTIMER22_KRN_CLK  ,1: USR_CNFG7 signal set to High"
    textline "                   "
    hexmask.long.byte 0x0 15.--15. 0x1 0x0 " SEL_SRC_DTIMER21_KRN_CLK  ,1: USR_CNFG7 signal set to High"
    textline "                   "
    hexmask.long.byte 0x0 16.--16. 0x1 0x0 " SEL_SRC_DTIMER12_KRN_CLK  ,1: USR_CNFG7 signal set to High"
    textline "                   "
    hexmask.long.byte 0x0 17.--17. 0x1 0x0 " SEL_SRC_DTIMER11_KRN_CLK  ,1: USR_CNFG7 signal set to High"
    textline "                   "
    hexmask.long.byte 0x0 18.--18. 0x1 0x0 " EN_SVID0_WKUP             ,1: CPUS INT_SVID0 wakeup source is enabled"
    textline "                   "
    hexmask.long.byte 0x0 19.--19. 0x1 0x0 " EN_SVID1_WKUP             ,1: CPUS INT_SVID1 wakeup source is enabled"
    textline "                   "
    hexmask.long.byte 0x0 20.--20. 0x1 0x0 " EN_AUX_EXTWKUP            ,1: CPUS EXT-3 wakeup source is enabled"
    textline "                   "
    hexmask.long.byte 0x0 21.--21. 0x1 0x0 " EN_PMBUS_WKUP             ,1: CPUS PMBUS_IRQ wakeup source is enabled"
    textline "                   "
    hexmask.long.byte 0x0 22.--22. 0x1 0x0 " EN_GPIO0_WKUP             ,1: CPUS GPIO0_IRQ wakeup source is enabled"
    textline "                   "
    hexmask.long.byte 0x0 23.--23. 0x1 0x0 " EN_GPIO1_WKUP             ,1: CPUS GPIO1_IRQ wakeup source is enabled"

; ---------------------- CPUS_CFG_SET member of scu ----------------------

  group 0x0004++0x0003
    line.long 0x000 "CPUS_CFG_SET, CPU Subsystem Configuration Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " SET_REMAP                 ,1: Remap signal set to 1"
    textline "                   "
    hexmask.long.byte 0x0 2.--2. 0x1 0x0 " DS_DBGPORT                ,1: DBG Port connection is disabled"
    textline "                   "
    hexmask.long.byte 0x0 3.--3. 0x1 0x0 " EN_EXTWKUP                ,1: CPUS Ext wakeup is enabled"
    textline "                   "
    hexmask.long.byte 0x0 4.--4. 0x1 0x0 " USR_CNFG0                 ,1: USR_CNFG0 signal set to High"
    textline "                   "
    hexmask.long.byte 0x0 5.--5. 0x1 0x0 " USR_CNFG1                 ,1: USR_CNFG1 signal set to High"
    textline "                   "
    hexmask.long.byte 0x0 6.--6. 0x1 0x0 " USR_CNFG2                 ,1: USR_CNFG2 signal set to High"
    textline "                   "
    hexmask.long.byte 0x0 7.--7. 0x1 0x0 " USR_CNFG3                 ,1: USR_CNFG3 signal set to High"
    textline "                   "
    hexmask.long.byte 0x0 8.--8. 0x1 0x0 " USR_CNFG4                 ,1: USR_CNFG4 signal set to High"
    textline "                   "
    hexmask.long.byte 0x0 9.--9. 0x1 0x0 " USR_CNFG5                 ,1: USR_CNFG5 signal set to High"
    textline "                   "
    hexmask.long.byte 0x0 10.--10. 0x1 0x0 " USR_CNFG6                 ,1: USR_CNFG6 signal set to High"
    textline "                   "
    hexmask.long.byte 0x0 11.--11. 0x1 0x0 " OTP_KEEP_PWR_ST           ,1: OTP keep power state after a reset"
    textline "                   "
    hexmask.long.byte 0x0 12.--12. 0x1 0x0 " SEL_SRC_DTIMER32_KRN_CLK  ,1: USR_CNFG7 signal set to High"
    textline "                   "
    hexmask.long.byte 0x0 13.--13. 0x1 0x0 " SEL_SRC_DTIMER31_KRN_CLK  ,1: USR_CNFG7 signal set to High"
    textline "                   "
    hexmask.long.byte 0x0 14.--14. 0x1 0x0 " SEL_SRC_DTIMER22_KRN_CLK  ,1: USR_CNFG7 signal set to High"
    textline "                   "
    hexmask.long.byte 0x0 15.--15. 0x1 0x0 " SEL_SRC_DTIMER21_KRN_CLK  ,1: USR_CNFG7 signal set to High"
    textline "                   "
    hexmask.long.byte 0x0 16.--16. 0x1 0x0 " SEL_SRC_DTIMER12_KRN_CLK  ,1: USR_CNFG7 signal set to High"
    textline "                   "
    hexmask.long.byte 0x0 17.--17. 0x1 0x0 " SEL_SRC_DTIMER11_KRN_CLK  ,1: USR_CNFG7 signal set to High"
    textline "                   "
    hexmask.long.byte 0x0 18.--18. 0x1 0x0 " EN_SVID0_WKUP             ,1: CPUS INT_SVID0 wakeup source is enabled"
    textline "                   "
    hexmask.long.byte 0x0 19.--19. 0x1 0x0 " EN_SVID1_WKUP             ,1: CPUS INT_SVID1 wakeup source is enabled"
    textline "                   "
    hexmask.long.byte 0x0 20.--20. 0x1 0x0 " EN_AUX_EXTWKUP            ,1: CPUS EXT-3 wakeup source is enabled"
    textline "                   "
    hexmask.long.byte 0x0 21.--21. 0x1 0x0 " EN_PMBUS_WKUP             ,1: CPUS PMBUS_IRQ wakeup source is enabled"
    textline "                   "
    hexmask.long.byte 0x0 22.--22. 0x1 0x0 " EN_GPIO0_WKUP             ,1: CPUS GPIO0_IRQ wakeup source is enabled"
    textline "                   "
    hexmask.long.byte 0x0 23.--23. 0x1 0x0 " EN_GPIO1_WKUP             ,1: CPUS GPIO1_IRQ wakeup source is enabled"

; ---------------------- CPUS_CFG_CLR member of scu ----------------------

  group 0x0008++0x0003
    line.long 0x000 "CPUS_CFG_CLR, CPU Subsystem Configuration Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " SET_REMAP                 ,1: Remap signal set to 1"
    textline "                   "
    hexmask.long.byte 0x0 2.--2. 0x1 0x0 " DS_DBGPORT                ,1: DBG Port connection is disabled"
    textline "                   "
    hexmask.long.byte 0x0 3.--3. 0x1 0x0 " EN_EXTWKUP                ,1: CPUS Ext wakeup is enabled"
    textline "                   "
    hexmask.long.byte 0x0 4.--4. 0x1 0x0 " USR_CNFG0                 ,1: USR_CNFG0 signal set to High"
    textline "                   "
    hexmask.long.byte 0x0 5.--5. 0x1 0x0 " USR_CNFG1                 ,1: USR_CNFG1 signal set to High"
    textline "                   "
    hexmask.long.byte 0x0 6.--6. 0x1 0x0 " USR_CNFG2                 ,1: USR_CNFG2 signal set to High"
    textline "                   "
    hexmask.long.byte 0x0 7.--7. 0x1 0x0 " USR_CNFG3                 ,1: USR_CNFG3 signal set to High"
    textline "                   "
    hexmask.long.byte 0x0 8.--8. 0x1 0x0 " USR_CNFG4                 ,1: USR_CNFG4 signal set to High"
    textline "                   "
    hexmask.long.byte 0x0 9.--9. 0x1 0x0 " USR_CNFG5                 ,1: USR_CNFG5 signal set to High"
    textline "                   "
    hexmask.long.byte 0x0 10.--10. 0x1 0x0 " USR_CNFG6                 ,1: USR_CNFG6 signal set to High"
    textline "                   "
    hexmask.long.byte 0x0 11.--11. 0x1 0x0 " OTP_KEEP_PWR_ST           ,1: OTP keep power state after a reset"
    textline "                   "
    hexmask.long.byte 0x0 12.--12. 0x1 0x0 " SEL_SRC_DTIMER32_KRN_CLK  ,1: USR_CNFG7 signal set to High"
    textline "                   "
    hexmask.long.byte 0x0 13.--13. 0x1 0x0 " SEL_SRC_DTIMER31_KRN_CLK  ,1: USR_CNFG7 signal set to High"
    textline "                   "
    hexmask.long.byte 0x0 14.--14. 0x1 0x0 " SEL_SRC_DTIMER22_KRN_CLK  ,1: USR_CNFG7 signal set to High"
    textline "                   "
    hexmask.long.byte 0x0 15.--15. 0x1 0x0 " SEL_SRC_DTIMER21_KRN_CLK  ,1: USR_CNFG7 signal set to High"
    textline "                   "
    hexmask.long.byte 0x0 16.--16. 0x1 0x0 " SEL_SRC_DTIMER12_KRN_CLK  ,1: USR_CNFG7 signal set to High"
    textline "                   "
    hexmask.long.byte 0x0 17.--17. 0x1 0x0 " SEL_SRC_DTIMER11_KRN_CLK  ,1: USR_CNFG7 signal set to High"
    textline "                   "
    hexmask.long.byte 0x0 18.--18. 0x1 0x0 " EN_SVID0_WKUP             ,1: CPUS INT_SVID0 wakeup source is enabled"
    textline "                   "
    hexmask.long.byte 0x0 19.--19. 0x1 0x0 " EN_SVID1_WKUP             ,1: CPUS INT_SVID1 wakeup source is enabled"
    textline "                   "
    hexmask.long.byte 0x0 20.--20. 0x1 0x0 " EN_AUX_EXTWKUP            ,1: CPUS EXT-3 wakeup source is enabled"
    textline "                   "
    hexmask.long.byte 0x0 21.--21. 0x1 0x0 " EN_PMBUS_WKUP             ,1: CPUS PMBUS_IRQ wakeup source is enabled"
    textline "                   "
    hexmask.long.byte 0x0 22.--22. 0x1 0x0 " EN_GPIO0_WKUP             ,1: CPUS GPIO0_IRQ wakeup source is enabled"
    textline "                   "
    hexmask.long.byte 0x0 23.--23. 0x1 0x0 " EN_GPIO1_WKUP             ,1: CPUS GPIO1_IRQ wakeup source is enabled"

; ----------------------- NMI_SRC_EN member of scu -----------------------

  group 0x000C++0x0003
    line.long 0x000 "NMI_SRC_EN, NMI Source Enable Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " EXT0_NMI_EN               ,Enable EXT0_IRQn as NMI"
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " INT_SVID0_NMI_EN          ,Enable INT_SVID0_IRQn as NMI"
    textline "                   "
    hexmask.long.byte 0x0 2.--2. 0x1 0x0 " INT_SVID1_NMI_EN          ,Enable INT_SVID1_IRQn as NMI"
    textline "                   "
    hexmask.long.byte 0x0 3.--3. 0x1 0x0 " CSC_NMI_EN                ,Enable CSC_IRQn as NMI"
    textline "                   "
    hexmask.long.byte 0x0 4.--4. 0x1 0x0 " PMBUS_NMI_EN              ,Enable PMBUS_IRQn as NMI"
    textline "                   "
    hexmask.long.byte 0x0 5.--5. 0x1 0x0 " OTP1_W_NMI_EN             ,Enable OTP1_W_IRQn as NMI"
    textline "                   "
    hexmask.long.byte 0x0 6.--6. 0x1 0x0 " EXT1_NMI_EN               ,Enable EXT1_IRQn as NMI"
    textline "                   "
    hexmask.long.byte 0x0 7.--7. 0x1 0x0 " EXT2_NMI_EN               ,Enable EXT2_IRQn as NMI"
    textline "                   "
    hexmask.long.byte 0x0 8.--8. 0x1 0x0 " EXT3_NMI_EN               ,Enable EXT3_IRQn as NMI"
    textline "                   "
    hexmask.long.byte 0x0 9.--9. 0x1 0x0 " EXT4_NMI_EN               ,Enable EXT4_IRQn as NMI"
    textline "                   "
    hexmask.long.byte 0x0 10.--10. 0x1 0x0 " EXT5_NMI_EN               ,Enable EXT5_IRQn as NMI"
    textline "                   "
    hexmask.long.byte 0x0 11.--11. 0x1 0x0 " EXT6_NMI_EN               ,Enable EXT6_IRQn as NMI"
    textline "                   "
    hexmask.long.byte 0x0 12.--12. 0x1 0x0 " WDT_NMI_EN                ,Enable WDT_IRQn as NMI"
    textline "                   "
    hexmask.long.byte 0x0 13.--13. 0x1 0x0 " DTIMER1_0_NMI_EN          ,Enable DTIMER1_0_IRQn as NMI"
    textline "                   "
    hexmask.long.byte 0x0 14.--14. 0x1 0x0 " DTIMER1_1_NMI_EN          ,Enable DTIMER1_1_IRQn as NMI"
    textline "                   "
    hexmask.long.byte 0x0 15.--15. 0x1 0x0 " DTIMER2_0_NMI_EN          ,Enable DTIMER2_0_IRQn as NMI"
    textline "                   "
    hexmask.long.byte 0x0 16.--16. 0x1 0x0 " DTIMER2_1_NMI_EN          ,Enable DTIMER2_1_IRQn as NMI"
    textline "                   "
    hexmask.long.byte 0x0 17.--17. 0x1 0x0 " DTIMER3_0_NMI_EN          ,Enable DTIMER3_0_IRQn as NMI"
    textline "                   "
    hexmask.long.byte 0x0 18.--18. 0x1 0x0 " DTIMER3_1_NMI_EN          ,Enable DTIMER3_1_IRQn as NMI"
    textline "                   "
    hexmask.long.byte 0x0 19.--19. 0x1 0x0 " GPIO0_NMI_EN              ,Enable GPIO0_IRQn as NMI"
    textline "                   "
    hexmask.long.byte 0x0 20.--20. 0x1 0x0 " GPIO1_NMI_EN              ,Enable GPIO1_IRQn as NMI"
    textline "                   "
    hexmask.long.byte 0x0 21.--21. 0x1 0x0 " FAULT_NMI_EN              ,Enable FAULT_IRQn as NMI"
    textline "                   "
    hexmask.long.byte 0x0 22.--22. 0x1 0x0 " TEST_NMI_EN               ,Enable TEST_IRQn as NMI"
    textline "                   "
    hexmask.long.byte 0x0 23.--23. 0x1 0x0 " VC0_VCONTROL_NMI_EN       ,Enable VC0_VCONTROL_IRQn as NMI"
    textline "                   "
    hexmask.long.byte 0x0 24.--24. 0x1 0x0 " VC1_VCONTROL_NMI_EN       ,Enable VC1_VCONTROL_IRQn as NMI"
    textline "                   "
    hexmask.long.byte 0x0 25.--25. 0x1 0x0 " TLM_NMI_EN                ,Enable TLM_IRQn as NMI"
    textline "                   "
    hexmask.long.byte 0x0 26.--26. 0x1 0x0 " FSW0_NMI_EN               ,Enable FSW0_IRQn as NMI"
    textline "                   "
    hexmask.long.byte 0x0 27.--27. 0x1 0x0 " FSW1_NMI_EN               ,Enable FSW1_IRQn as NMI"
    textline "                   "
    hexmask.long.byte 0x0 28.--28. 0x1 0x0 " DMA_NMI_EN                ,Enable DMA_IRQn as NMI"
    textline "                   "
    hexmask.long.byte 0x0 29.--29. 0x1 0x0 " SSP_NMI_EN                ,Enable SSP_IRQn as NMI"
    textline "                   "
    hexmask.long.byte 0x0 30.--30. 0x1 0x0 " I2C_NMI_EN                ,Enable I2C_IRQn as NMI"
    textline "                   "
    hexmask.long.byte 0x0 31.--31. 0x1 0x0 " UART_NMI_EN               ,Enable UART_IRQn as NMI"

; -------------------------- DRVR member of scu --------------------------

  group 0x0010++0x0003
    line.long 0x000 "DRVR, MSM Status Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DRV                       ,1: lp2_st_ss is high"

; -------------------------- MONR member of scu --------------------------

  rgroup 0x0014++0x0003
    line.long 0x000 "MONR, MSM Status Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " MON                       ,1: st_test is high"
    textline "                   "
    hexmask.long.byte 0x0 8.--8. 0x1 0x0 " CPUSENSTAT                ,1: CPUS_EN is high"

; ------------------------ SPARE_FF member of scu ------------------------

  group 0x0020++0x0003
    line.long 0x000 "SPARE_FF, Spare Register"
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " SPARE_FF                  ,Spare Register"

tree.end

; -------------------------------------------------------------------
; End Block - scu
; -------------------------------------------------------------------
tree.end
; @file:      ssp.per
; Chip name:  SHASTA
; Module:     ssp
; 
; Generated by the pmm metagen library.
;
; ===================================================================
; Copyright (C) 2018 Infineon Technologies AG
; All rights reserved.
; ===================================================================
;
; ===================================================================
; This document contains proprietary information. Passing on and
; copying of this document, and communication of its contents is not
; permitted without prior written authorisation.
; ===================================================================

; This file is automatically generated. Do not edit!


config 32. 8.
width 20.

tree "Block - ssp"
; -------------------------------------------------------------------
; Begin Block - ssp
; -------------------------------------------------------------------
base D:0x700A0000

tree "ssp"
; ------------------------- SSPCR0 member of ssp -------------------------

  group 0x0000++0x0003
    line.long 0x000 "SSPCR0, Control Register 0"
    textline "                   "
    bitfld.long 0x0 0.--3. " DSS                       ,Data Size Select" "Const_0b0000 (0),Const_0b0001 (1),Const_0b0010 (2),Const_0b0011 (3),Const_0b0100 (4),Const_0b0101 (5),Const_0b0110 (6),Const_0b0111 (7),Const_0b1000 (8),Const_0b1001 (9),Const_0b1010 (a),Const_0b1011 (b),Const_0b1100 (c),Const_0b1101 (d),Const_0b1110 (e),Const_0b1111 (f)"
    textline "                   "
    bitfld.long 0x0 4.--5. " FRF                       ,Frame Format" "Const_0b00 (0),Const_0b01 (1),Const_0b10 (2),Const_0b11 (3)"
    textline "                   "
    hexmask.long.byte 0x0 6.--6. 0x1 0x0 " SPO                       ,SSPCLKOUT Polarity"
    textline "                   "
    hexmask.long.byte 0x0 7.--7. 0x1 0x0 " SPH                       ,SSPCLKOUT Phase"
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " SCR                       ,Serial clock rate"

; ------------------------- SSPCR1 member of ssp -------------------------

  group 0x0004++0x0003
    line.long 0x000 "SSPCR1, Control Register 1"
    textline "                   "
    bitfld.long 0x0 0. " LBM                       ,Loop back mode" "Const_0b0 (0),Const_0b1 (1)"
    textline "                   "
    bitfld.long 0x0 1. " SSE                       ,Synchronous serial port enable" "Const_0b0 (0),Const_0b1 (1)"
    textline "                   "
    bitfld.long 0x0 2. " MS                        ,Master or slave mode select" "Const_0b0 (0),Const_0b1 (1)"
    textline "                   "
    bitfld.long 0x0 3. " SOD                       ,Slave-mode output disable" "Const_0b0 (0),Const_0b1 (1)"
    textline "                   "
    hexmask.long.long 0x0 4.--31. 0x1 0x0 " RES                       ,Reserved, read unpredictable, should be written    as 0."

; ------------------------- SSPDR member of ssp -------------------------

  group 0x0008++0x0003
    line.long 0x000 "SSPDR, Data Register"
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " DATA                      ,Transmit/Receive FIFO"
    textline "                   "
    hexmask.long.word 0x0 16.--31. 0x1 0x0 " RES                       ,Reserved, read unpredictable, should be written    as 0."

; ------------------------- SSPSR member of ssp -------------------------

  rgroup 0x000C++0x0003
    line.long 0x000 "SSPSR, Status Register"
    textline "                   "
    bitfld.long 0x0 0. " TFE                       ,Transmit FIFO empty" "Const_0b0 (0),Const_0b1 (1)"
    textline "                   "
    bitfld.long 0x0 1. " TNF                       ,Transmit FIFO not full" "Const_0b0 (0),Const_0b1 (1)"
    textline "                   "
    bitfld.long 0x0 2. " RNE                       ,Receive FIFO not empty" "Const_0b0 (0),Const_0b1 (1)"
    textline "                   "
    bitfld.long 0x0 3. " RFF                       ,Receive FIFO full" "Const_0b0 (0),Const_0b1 (1)"
    textline "                   "
    bitfld.long 0x0 4. " BSY                       ,PrimeCell SSP busy flag" "Const_0b0 (0),Const_0b1 (1)"
    textline "                   "
    hexmask.long.long 0x0 5.--31. 0x1 0x0 " RES                       ,Reserved, read unpredictable, should be written    as 0."

; ------------------------ SSPCPSR member of ssp ------------------------

  group 0x0010++0x0003
    line.long 0x000 "SSPCPSR, Clock Prescale Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " CPSDVSR                   ,Clock prescale divisor"
    textline "                   "
    hexmask.long.long 0x0 8.--31. 0x1 0x0 " RES                       ,Reserved, read unpredictable, should be written    as 0."

; ------------------------ SSPIMSC member of ssp ------------------------

  group 0x0014++0x0003
    line.long 0x000 "SSPIMSC, Interrupt Mask Set or Clear Register"
    textline "                   "
    bitfld.long 0x0 0. " RORIM                     ,Receive overrun interrupt mask" "Const_0b0 (0),Const_0b1 (1)"
    textline "                   "
    bitfld.long 0x0 1. " RTIM                      ,Receive timeout interrupt mask" "Const_0b0 (0),Const_0b1 (1)"
    textline "                   "
    bitfld.long 0x0 2. " RXIM                      ,Receive FIFO interrupt mask" "Const_0b0 (0),Const_0b1 (1)"
    textline "                   "
    bitfld.long 0x0 3. " TXIM                      ,Transmit FIFO interrupt mask" "Const_0b0 (0),Const_0b1 (1)"
    textline "                   "
    hexmask.long.long 0x0 4.--31. 0x1 0x0 " RES                       ,Reserved, read as zero, do not modify."

; ------------------------- SSPRIS member of ssp -------------------------

  rgroup 0x0018++0x0003
    line.long 0x000 "SSPRIS, Raw Interrupt Status Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " RORRIS                    ,SSPRORINTR Raw Interrupt Status"
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " RTRIS                     ,SSPRTINTR Raw Interrupt Status"
    textline "                   "
    hexmask.long.byte 0x0 2.--2. 0x1 0x0 " RXRIS                     ,SSPRXINTR Raw Interrupt Status"
    textline "                   "
    hexmask.long.byte 0x0 3.--3. 0x1 0x0 " TXRIS                     ,SSPTXINTR Raw Interrupt Status"
    textline "                   "
    hexmask.long.long 0x0 4.--31. 0x1 0x0 " RES                       ,Reserved, read as zero, do not modify."

; ------------------------- SSPMIS member of ssp -------------------------

  rgroup 0x001C++0x0003
    line.long 0x000 "SSPMIS, Masked Interrupt Status Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " RORMIS                    ,SSPRORINTR Masked Interrupt Status"
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " RTMIS                     ,SSPRTINTR Masked Interrupt Status"
    textline "                   "
    hexmask.long.byte 0x0 2.--2. 0x1 0x0 " RXMIS                     ,SSPRXINTR Masked Interrupt Status"
    textline "                   "
    hexmask.long.byte 0x0 3.--3. 0x1 0x0 " TXMIS                     ,SSPTXINTR Masked Interrupt Status"
    textline "                   "
    hexmask.long.long 0x0 4.--31. 0x1 0x0 " RES                       ,Reserved, read as zero, do not modify."

; ------------------------- SSPICR member of ssp -------------------------

  group 0x0020++0x0003
    line.long 0x000 "SSPICR, Interrupt Clear Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " RORIC                     ,SSPRORINTR Interrupt Clear Bit"
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " RTIC                      ,SSPRTINTR Interrupt Clear Bit"
    textline "                   "
    hexmask.long.long 0x0 2.--31. 0x1 0x0 " RES                       ,Reserved, read as zero, do not modify."

; ------------------------ SSPDMACR member of ssp ------------------------

  group 0x0024++0x0003
    line.long 0x000 "SSPDMACR, DMA Control Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " RXDMAE                    ,Receive DMA Enable"
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " TXDMAE                    ,Transmit DMA Enable"
    textline "                   "
    hexmask.long.long 0x0 2.--31. 0x1 0x0 " RES                       ,Reserved, read as zero, do not modify."

; ------------------------- SSPTCR member of ssp -------------------------

  group 0x0080++0x0003
    line.long 0x000 "SSPTCR, Test Control Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " ITEN                      ,Integration Test Enable"
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " TESTFIFO                  ,Test FIFO Enable"
    textline "                   "
    hexmask.long.long 0x0 2.--31. 0x1 0x0 " RES                       ,Reserved, unpredictable when read."

; ------------------------ SSPITIP member of ssp ------------------------

  group 0x0084++0x0003
    line.long 0x000 "SSPITIP, Integration Test Input Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " SSPRXD                    ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " SSPFSSIN                  ,"
    textline "                   "
    hexmask.long.byte 0x0 2.--2. 0x1 0x0 " SSPCLKIN                  ,"
    textline "                   "
    hexmask.long.byte 0x0 3.--3. 0x1 0x0 " SSPRXDMACLR               ,"
    textline "                   "
    hexmask.long.byte 0x0 4.--4. 0x1 0x0 " SSPTXDMACLR               ,"
    textline "                   "
    hexmask.long.long 0x0 5.--31. 0x1 0x0 " RES                       ,Reserved, unpredictable when read."

; ------------------------ SSPITOP member of ssp ------------------------

  group 0x0088++0x0003
    line.long 0x000 "SSPITOP, Integration Test Output Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " SSPTXD                    ,"
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " SSPFSSOUT                 ,"
    textline "                   "
    hexmask.long.byte 0x0 2.--2. 0x1 0x0 " SSPCLKOUT                 ,"
    textline "                   "
    hexmask.long.byte 0x0 3.--3. 0x1 0x0 " nSSPOE                    ,"
    textline "                   "
    hexmask.long.byte 0x0 4.--4. 0x1 0x0 " nSSPCTLOE                 ,"
    textline "                   "
    hexmask.long.byte 0x0 5.--5. 0x1 0x0 " SSPRORINTR                ,"
    textline "                   "
    hexmask.long.byte 0x0 6.--6. 0x1 0x0 " SSPRTINTR                 ,"
    textline "                   "
    hexmask.long.byte 0x0 7.--7. 0x1 0x0 " SSPRXINTR                 ,"
    textline "                   "
    hexmask.long.byte 0x0 8.--8. 0x1 0x0 " SSPTXINTR                 ,"
    textline "                   "
    hexmask.long.byte 0x0 9.--9. 0x1 0x0 " SSPINTR                   ,"
    textline "                   "
    hexmask.long.byte 0x0 10.--10. 0x1 0x0 " SSPRXDMABREQ              ,"
    textline "                   "
    hexmask.long.byte 0x0 11.--11. 0x1 0x0 " SSPRXDMASREQ              ,"
    textline "                   "
    hexmask.long.byte 0x0 12.--12. 0x1 0x0 " SSPTXDMABREQ              ,"
    textline "                   "
    hexmask.long.byte 0x0 13.--13. 0x1 0x0 " SSPTXDMASREQ              ,"
    textline "                   "
    hexmask.long.long 0x0 14.--31. 0x1 0x0 " RES                       ,Reserved, unpredictable when read."

; ------------------------- SSPTDR member of ssp -------------------------

  group 0x008C++0x0003
    line.long 0x000 "SSPTDR, Test Data Register"
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " DATA                      ,Test Data"
    textline "                   "
    hexmask.long.word 0x0 16.--31. 0x1 0x0 " RES                       ,Reserved, unpredictable when read."

; ---------------------- SSPPeriphID0 member of ssp ----------------------

  rgroup 0x0FE0++0x0003
    line.long 0x000 "SSPPeriphID0, Peripheral Identification Register 0"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " PartNumber0               ,Part Number 0"
    textline "                   "
    hexmask.long.long 0x0 8.--31. 0x1 0x0 " RES                       ,Reserved, read undefined, must read as zeros."

; ---------------------- SSPPeriphID1 member of ssp ----------------------

  rgroup 0x0FE4++0x0003
    line.long 0x000 "SSPPeriphID1, Peripheral Identification Register 1"
    textline "                   "
    hexmask.long.byte 0x0 0.--3. 0x1 0x0 " PartNumber1               ,Part Number 1"
    textline "                   "
    hexmask.long.byte 0x0 4.--7. 0x1 0x0 " Designer0                 ,Designer Number 0"
    textline "                   "
    hexmask.long.long 0x0 8.--31. 0x1 0x0 " RES                       ,Reserved, read undefined, must read as zeros."

; ---------------------- SSPPeriphID2 member of ssp ----------------------

  rgroup 0x0FE8++0x0003
    line.long 0x000 "SSPPeriphID2, Peripheral Identification Register 2"
    textline "                   "
    hexmask.long.byte 0x0 0.--3. 0x1 0x0 " Designer1                 ,Designer Number 1"
    textline "                   "
    hexmask.long.byte 0x0 4.--7. 0x1 0x0 " Revision                  ,Revision Number"
    textline "                   "
    hexmask.long.long 0x0 8.--31. 0x1 0x0 " RES                       ,Reserved, read undefined, must read as zeros."

; ---------------------- SSPPeriphID3 member of ssp ----------------------

  rgroup 0x0FEC++0x0003
    line.long 0x000 "SSPPeriphID3, Peripheral Identification Register 3"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " Configuration             ,Configuration Number"
    textline "                   "
    hexmask.long.long 0x0 8.--31. 0x1 0x0 " RES                       ,Reserved, read undefined, must read as zeros."

; ---------------------- SSPPCellID0 member of ssp ----------------------

  rgroup 0x0FF0++0x0003
    line.long 0x000 "SSPPCellID0, PrimeCell Identification Register 0"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " SSPPCellID0               ,Cell Identification Number 0"
    textline "                   "
    hexmask.long.long 0x0 8.--31. 0x1 0x0 " RES                       ,Reserved, read undefined, must read as zeros."

; ---------------------- SSPPCellID1 member of ssp ----------------------

  rgroup 0x0FF4++0x0003
    line.long 0x000 "SSPPCellID1, PrimeCell Identification Register 1"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " SSPPCellID1               ,Cell Identification Number 1"
    textline "                   "
    hexmask.long.long 0x0 8.--31. 0x1 0x0 " RES                       ,Reserved, read undefined, must read as zeros."

; ---------------------- SSPPCellID2 member of ssp ----------------------

  rgroup 0x0FF8++0x0003
    line.long 0x000 "SSPPCellID2, PrimeCell Identification Register 2"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " SSPPCellID2               ,Cell Identification Number 2"
    textline "                   "
    hexmask.long.long 0x0 8.--31. 0x1 0x0 " RES                       ,Reserved, read undefined, must read as zeros."

; ---------------------- SSPPCellID3 member of ssp ----------------------

  rgroup 0x0FFC++0x0003
    line.long 0x000 "SSPPCellID3, PrimeCell Identification Register 3"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " SSPPCellID3               ,Cell Identification Number 3"
    textline "                   "
    hexmask.long.long 0x0 8.--31. 0x1 0x0 " RES                       ,Reserved, read undefined, must read as zeros."

tree.end

; -------------------------------------------------------------------
; End Block - ssp
; -------------------------------------------------------------------
tree.end
; @file:      telem.per
; Chip name:  SHASTA
; Module:     telem
; 
; Generated by the pmm metagen library.
;
; ===================================================================
; Copyright (C) 2018 Infineon Technologies AG
; All rights reserved.
; ===================================================================
;
; ===================================================================
; This document contains proprietary information. Passing on and
; copying of this document, and communication of its contents is not
; permitted without prior written authorisation.
; ===================================================================

; This file is automatically generated. Do not edit!


config 32. 8.
width 20.

tree "Block - telem"
; -------------------------------------------------------------------
; Begin Block - telem
; -------------------------------------------------------------------
base D:0x70003400

tree "telem0"
; ----------------------- TLM_CFG1 member of telem -----------------------

  group 0x0000++0x0003
    line.long 0x000 "TLM_CFG1, Duty cycle telemetry LPF coefficient index.  Note that exp settings greater than 9 are clamped to 9.  Set to 63 to bypass filter. "
    textline "                   "
    hexmask.long.byte 0x0 0.--5. 0x1 0x0 " tlm_kfp_duty              ,Duty cycle telemetry LPF coefficient index.  Note that exp settings greater than 9 are clamped to 9.  Set to 63 to bypass filter. "
    textline "                   "
    hexmask.long.byte 0x0 6.--11. 0x1 0x0 " tlm_iin_est_alpha         ,Input current estimate alpha coefficient, U0.6.  Defines relative contributions of Vout/Vin and Duty Cycle in computation as follows: "
    textline "                   "
    hexmask.long.byte 0x0 12.--13. 0x1 0x0 " tlm_iin_src_sel           ,Input current telemetry source select. "
    textline "                   "
    hexmask.long.byte 0x0 14.--19. 0x1 0x0 " tlm_kfp_iin               ,Input current telemetry LPF coefficient index.  Note that exp settings greater than 9 are clamped to 9.  Set to 63 to bypass filter. "
    textline "                   "
    hexmask.long.byte 0x0 20.--21. 0x1 0x0 " tlm_iout_src_sel          ,Output current telemetry source select. "
    textline "                   "
    hexmask.long.byte 0x0 22.--27. 0x1 0x0 " tlm_kfp_iout              ,Output current telemetry LPF coefficient index.  Note that exp settings greater than 9 are clamped to 9.  Set to 63 to bypass filter. "
    textline "                   "
    hexmask.long.byte 0x0 28.--30. 0x1 0x0 " tlm_vin_src_sel           ,Input voltage telemetry source select. "

; ----------------------- TLM_CFG2 member of telem -----------------------

  group 0x0004++0x0003
    line.long 0x000 "TLM_CFG2, Input voltage telemetry LPF coefficient index.  Note that exp settings greater than 9 are clamped to 9.  Set to 63 to bypass filter. "
    textline "                   "
    hexmask.long.byte 0x0 0.--5. 0x1 0x0 " tlm_kfp_vin               ,Input voltage telemetry LPF coefficient index.  Note that exp settings greater than 9 are clamped to 9.  Set to 63 to bypass filter. "
    textline "                   "
    hexmask.long.byte 0x0 6.--11. 0x1 0x0 " tlm_kfp_vout              ,Output voltage telemetry LPF coefficient index.  Note that exp settings greater than 7 are clamped to 7.  Set to 63 to bypass filter. "
    textline "                   "
    hexmask.long.byte 0x0 12.--17. 0x1 0x0 " tlm_vrect_rcorr           ,Resistive correction term applied to rectification voltage (Vrect) computation.  This term is multipled by the output current and added to the Vrect value from the ADC.  The user should enter the effective resistance as seen at the VRSEN input  the Vrect sense resistor divider."
    textline "                   "
    hexmask.long.byte 0x0 18.--24. 0x1 0x0 " tlm_vrect_voffset         ,Voltage offset correction term applied to the rectification voltage (Vrect) computation.  This term is added to the Vrect value from the ADC.  The user should enter the effective offset as seen at the VRSEN input  the Vrect sense resistor divider."
    textline "                   "
    hexmask.long.byte 0x0 25.--27. 0x1 0x0 " tlm_vrect_sr_diode        ,Voltage correction term on Vrect computation when SR FETs are off.  Intended to compensate for 1 or 2 series body diodes.  The user should enter the diode drop as seen at the rectification voltage "

; --------------------- TLM_DUTY_FSW member of telem ---------------------

  rgroup 0x0008++0x0003
    line.long 0x000 "TLM_DUTY_FSW, Low pass filtered duty cycle telemetry updated at Fswitch rate PMBus command computed as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " tlm_duty_fsw              ,Low pass filtered duty cycle telemetry updated at Fswitch rate PMBus command computed as follows: "

; ----------------------- TLM_FREQ member of telem -----------------------

  rgroup 0x000C++0x0003
    line.long 0x000 "TLM_FREQ, Switching frequency telemetry inlcuding possible adjustment due to external SYNC. PMBus command computed as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--10. 0x1 0x0 " tlm_freq                  ,Switching frequency telemetry inlcuding possible adjustment due to external SYNC. PMBus command computed as follows: "

; --------------------- TLM_IIN_LPF member of telem ---------------------

  rgroup 0x0010++0x0003
    line.long 0x000 "TLM_IIN_LPF, Low pass filtered input current telemetry updated at Fswitch rate. PMBus command computed as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--12. 0x1 0x0 " tlm_iin_lpf               ,Low pass filtered input current telemetry updated at Fswitch rate. PMBus command computed as follows: "

; --------------------- TLM_IIN_EST member of telem ---------------------

  rgroup 0x0014++0x0003
    line.long 0x000 "TLM_IIN_EST, Result of estimated input current computation based on Iout, Vout, Vin and Duty Cycle values."
    textline "                   "
    hexmask.long.word 0x0 0.--12. 0x1 0x0 " tlm_iin_est               ,Result of estimated input current computation based on Iout, Vout, Vin and Duty Cycle values."

; ------------------- TLM_VOUT_DIV_VIN member of telem -------------------

  rgroup 0x0018++0x0003
    line.long 0x000 "TLM_VOUT_DIV_VIN, Result of equation (Vout / Vin) computed during input current estimation."
    textline "                   "
    hexmask.long.word 0x0 0.--11. 0x1 0x0 " tlm_vout_div_vin          ,Result of equation (Vout / Vin) computed during input current estimation."

; --------------------- TLM_IOUT_FS member of telem ---------------------

  rgroup 0x001C++0x0003
    line.long 0x000 "TLM_IOUT_FS, Cycle averged output current updated at Fswitch rate."
    textline "                   "
    hexmask.long.word 0x0 0.--12. 0x1 0x0 " tlm_iout_fs               ,Cycle averged output current updated at Fswitch rate."

; --------------------- TLM_IOUT_FSW member of telem ---------------------

  rgroup 0x0020++0x0003
    line.long 0x000 "TLM_IOUT_FSW, Low pas filtered output current telemetry updated at Fswitch rate PMBus command computed as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--12. 0x1 0x0 " tlm_iout_fsw              ,Low pas filtered output current telemetry updated at Fswitch rate PMBus command computed as follows: "

; -------------------- TLM_VIN_FORCE member of telem --------------------

  group 0x0024++0x0003
    line.long 0x000 "TLM_VIN_FORCE, Forced Vin input value.  Selected as source for Vin by tlm_vin_src_sel."
    textline "                   "
    hexmask.long.word 0x0 0.--10. 0x1 0x0 " tlm_vin_force             ,Forced Vin input value.  Selected as source for Vin by tlm_vin_src_sel."

; ------------------ TLM_VI_CNVRT_FACT member of telem ------------------

  group 0x0028++0x0003
    line.long 0x000 "TLM_VI_CNVRT_FACT, Conversion factor for computing Vin from the measured VS ADC output.  It consists of 3 components: scaling for the Vrect resistor divider, scaling for the tranformer / topology and shifting the binary point from the ADC representation (1.25mV) to 1V. Computed from PMBus commands as follows: "
    textline "                   "
    hexmask.long.long 0x0 0.--21. 0x1 0x0 " tlm_vin_convert_factor    ,Conversion factor for computing Vin from the measured VS ADC output.  It consists of 3 components: scaling for the Vrect resistor divider, scaling for the tranformer / topology and shifting the binary point from the ADC representation (1.25mV) to 1V. Computed from PMBus commands as follows: "

; --------------------- TLM_VIN_LPF member of telem ---------------------

  rgroup 0x002C++0x0003
    line.long 0x000 "TLM_VIN_LPF, Low pass filtered input voltage telemetry. PMBus command computed as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--10. 0x1 0x0 " tlm_vin_lpf               ,Low pass filtered input voltage telemetry. PMBus command computed as follows: "

; ------------------ TLM_VO_CNVRT_FACT member of telem ------------------

  group 0x0030++0x0003
    line.long 0x000 "TLM_VO_CNVRT_FACT, Conversion factor for computing Vout from the measured VS ADC output.  It consists of 2 components: scaling for the Vout resistor divider and shifting the binary point from the ADC representation (1.25mV) to 1V. Computed from PMBus commands as follows: "
    textline "                   "
    hexmask.long.long 0x0 0.--20. 0x1 0x0 " tlm_vout_convert_factor   ,Conversion factor for computing Vout from the measured VS ADC output.  It consists of 2 components: scaling for the Vout resistor divider and shifting the binary point from the ADC representation (1.25mV) to 1V. Computed from PMBus commands as follows: "

; --------------------- TLM_VOUT_FS member of telem ---------------------

  rgroup 0x0034++0x0003
    line.long 0x000 "TLM_VOUT_FS, Output voltage (Vout) telemetry at the sample clock rate (50MHz).  This field is in VS ADC code format (i.e., the voltage at the VSEN pin after the sense resistor divider) and must be scaled by VOUT_SCALE_LOOP for output referenced voltage.  See tlm_vout_fsw description for scale equation."
    textline "                   "
    hexmask.long.word 0x0 0.--11. 0x1 0x0 " tlm_vout_fs               ,Output voltage (Vout) telemetry at the sample clock rate (50MHz).  This field is in VS ADC code format (i.e., the voltage at the VSEN pin after the sense resistor divider) and must be scaled by VOUT_SCALE_LOOP for output referenced voltage.  See tlm_vout_fsw description for scale equation."

; --------------------- TLM_VOUT_FSW member of telem ---------------------

  rgroup 0x0038++0x0003
    line.long 0x000 "TLM_VOUT_FSW, Low pass filtered output voltage (Vout) telemetry updated at the Fswitch clock rate. "
    textline "                   "
    hexmask.long.word 0x0 0.--14. 0x1 0x0 " tlm_vout_fsw              ,Low pass filtered output voltage (Vout) telemetry updated at the Fswitch clock rate. "

; ------------------ TLM_TRNS_SCALE_LP member of telem ------------------

  group 0x003C++0x0003
    line.long 0x000 "TLM_TRNS_SCALE_LP, Ratio of Vrect to Vin.  For Half-Bridge equal to Nturn_sec / (2 * Nturn_pri), otherwise equal to Nturn_sec / Nturn_pri. Computed from PMBus as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--11. 0x1 0x0 " tlm_transformer_scale_lo? ,Ratio of Vrect to Vin.  For Half-Bridge equal to Nturn_sec / (2 * Nturn_pri), otherwise equal to Nturn_sec / Nturn_pri. Computed from PMBus as follows: "

; ----------------- TLM_VRECT_SCALE_LOOP member of telem -----------------

  group 0x0040++0x0003
    line.long 0x000 "TLM_VRECT_SCALE_LO?, Vrect sense resitor scale value. Computed from PMBus as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--11. 0x1 0x0 " tlm_vrect_scale_loop      ,Vrect sense resitor scale value. Computed from PMBus as follows: "

; ----------------- TLM_VOUT_SCALE_LOOP member of telem -----------------

  group 0x0044++0x0003
    line.long 0x000 "TLM_VOUT_SCALE_LOOP, Vout sense resitor scale value Computed from PMBus as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " tlm_vout_scale_loop       ,Vout sense resitor scale value Computed from PMBus as follows: "

; --------------------- TLM_HILO_SEL member of telem ---------------------

  group 0x0048++0x0003
    line.long 0x000 "TLM_HILO_SEL, Input select for Hi/Lo watermark detector A "
    textline "                   "
    hexmask.long.byte 0x0 0.--1. 0x1 0x0 " tlm_hilo_mark_A_sel       ,Input select for Hi/Lo watermark detector A "
    textline "                   "
    hexmask.long.byte 0x0 2.--3. 0x1 0x0 " tlm_hilo_mark_B_sel       ,Input select for Hi/Lo watermark detector B "

; -------------------- TLM_HILO_CLRA member of telem --------------------

  group 0x004C++0x0003
    line.long 0x000 "TLM_HILO_CLRA, Clear for Hi/Lo watermark detector A"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " tlm_hilo_mark_A_clr       ,Clear for Hi/Lo watermark detector A"

; -------------------- TLM_HILO_CLRB member of telem --------------------

  group 0x0050++0x0003
    line.long 0x000 "TLM_HILO_CLRB, Clear for Hi/Lo watermark detector B"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " tlm_hilo_mark_B_clr       ,Clear for Hi/Lo watermark detector B"

; -------------------- TLM_HILO_OUTA member of telem --------------------

  rgroup 0x0054++0x0003
    line.long 0x000 "TLM_HILO_OUTA, High watermark detector A output.  Format depends on input selected by tlm_hilo_mark_A_sel."
    textline "                   "
    hexmask.long.word 0x0 0.--12. 0x1 0x0 " tlm_out_hi_A              ,High watermark detector A output.  Format depends on input selected by tlm_hilo_mark_A_sel."
    textline "                   "
    hexmask.long.word 0x0 13.--25. 0x1 0x0 " tlm_out_lo_A              ,Low watermark detector A output.  Format depends on input selected by tlm_hilo_mark_A_sel."

; -------------------- TLM_HILO_OUTB member of telem --------------------

  rgroup 0x0058++0x0003
    line.long 0x000 "TLM_HILO_OUTB, High watermark detector B output.  Format depends on input selected by tlm_hilo_mark_B_sel."
    textline "                   "
    hexmask.long.word 0x0 0.--12. 0x1 0x0 " tlm_out_hi_B              ,High watermark detector B output.  Format depends on input selected by tlm_hilo_mark_B_sel."
    textline "                   "
    hexmask.long.word 0x0 13.--25. 0x1 0x0 " tlm_out_lo_B              ,Low watermark detector B output.  Format depends on input selected by tlm_hilo_mark_B_sel."

tree.end
base D:0x70003800

tree "telem1"
; ----------------------- TLM_CFG1 member of telem -----------------------

  group 0x0000++0x0003
    line.long 0x000 "TLM_CFG1, Duty cycle telemetry LPF coefficient index.  Note that exp settings greater than 9 are clamped to 9.  Set to 63 to bypass filter. "
    textline "                   "
    hexmask.long.byte 0x0 0.--5. 0x1 0x0 " tlm_kfp_duty              ,Duty cycle telemetry LPF coefficient index.  Note that exp settings greater than 9 are clamped to 9.  Set to 63 to bypass filter. "
    textline "                   "
    hexmask.long.byte 0x0 6.--11. 0x1 0x0 " tlm_iin_est_alpha         ,Input current estimate alpha coefficient, U0.6.  Defines relative contributions of Vout/Vin and Duty Cycle in computation as follows: "
    textline "                   "
    hexmask.long.byte 0x0 12.--13. 0x1 0x0 " tlm_iin_src_sel           ,Input current telemetry source select. "
    textline "                   "
    hexmask.long.byte 0x0 14.--19. 0x1 0x0 " tlm_kfp_iin               ,Input current telemetry LPF coefficient index.  Note that exp settings greater than 9 are clamped to 9.  Set to 63 to bypass filter. "
    textline "                   "
    hexmask.long.byte 0x0 20.--21. 0x1 0x0 " tlm_iout_src_sel          ,Output current telemetry source select. "
    textline "                   "
    hexmask.long.byte 0x0 22.--27. 0x1 0x0 " tlm_kfp_iout              ,Output current telemetry LPF coefficient index.  Note that exp settings greater than 9 are clamped to 9.  Set to 63 to bypass filter. "
    textline "                   "
    hexmask.long.byte 0x0 28.--30. 0x1 0x0 " tlm_vin_src_sel           ,Input voltage telemetry source select. "

; ----------------------- TLM_CFG2 member of telem -----------------------

  group 0x0004++0x0003
    line.long 0x000 "TLM_CFG2, Input voltage telemetry LPF coefficient index.  Note that exp settings greater than 9 are clamped to 9.  Set to 63 to bypass filter. "
    textline "                   "
    hexmask.long.byte 0x0 0.--5. 0x1 0x0 " tlm_kfp_vin               ,Input voltage telemetry LPF coefficient index.  Note that exp settings greater than 9 are clamped to 9.  Set to 63 to bypass filter. "
    textline "                   "
    hexmask.long.byte 0x0 6.--11. 0x1 0x0 " tlm_kfp_vout              ,Output voltage telemetry LPF coefficient index.  Note that exp settings greater than 7 are clamped to 7.  Set to 63 to bypass filter. "
    textline "                   "
    hexmask.long.byte 0x0 12.--17. 0x1 0x0 " tlm_vrect_rcorr           ,Resistive correction term applied to rectification voltage (Vrect) computation.  This term is multipled by the output current and added to the Vrect value from the ADC.  The user should enter the effective resistance as seen at the VRSEN input  the Vrect sense resistor divider."
    textline "                   "
    hexmask.long.byte 0x0 18.--24. 0x1 0x0 " tlm_vrect_voffset         ,Voltage offset correction term applied to the rectification voltage (Vrect) computation.  This term is added to the Vrect value from the ADC.  The user should enter the effective offset as seen at the VRSEN input  the Vrect sense resistor divider."
    textline "                   "
    hexmask.long.byte 0x0 25.--27. 0x1 0x0 " tlm_vrect_sr_diode        ,Voltage correction term on Vrect computation when SR FETs are off.  Intended to compensate for 1 or 2 series body diodes.  The user should enter the diode drop as seen at the rectification voltage "

; --------------------- TLM_DUTY_FSW member of telem ---------------------

  rgroup 0x0008++0x0003
    line.long 0x000 "TLM_DUTY_FSW, Low pass filtered duty cycle telemetry updated at Fswitch rate PMBus command computed as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " tlm_duty_fsw              ,Low pass filtered duty cycle telemetry updated at Fswitch rate PMBus command computed as follows: "

; ----------------------- TLM_FREQ member of telem -----------------------

  rgroup 0x000C++0x0003
    line.long 0x000 "TLM_FREQ, Switching frequency telemetry inlcuding possible adjustment due to external SYNC. PMBus command computed as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--10. 0x1 0x0 " tlm_freq                  ,Switching frequency telemetry inlcuding possible adjustment due to external SYNC. PMBus command computed as follows: "

; --------------------- TLM_IIN_LPF member of telem ---------------------

  rgroup 0x0010++0x0003
    line.long 0x000 "TLM_IIN_LPF, Low pass filtered input current telemetry updated at Fswitch rate. PMBus command computed as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--12. 0x1 0x0 " tlm_iin_lpf               ,Low pass filtered input current telemetry updated at Fswitch rate. PMBus command computed as follows: "

; --------------------- TLM_IIN_EST member of telem ---------------------

  rgroup 0x0014++0x0003
    line.long 0x000 "TLM_IIN_EST, Result of estimated input current computation based on Iout, Vout, Vin and Duty Cycle values."
    textline "                   "
    hexmask.long.word 0x0 0.--12. 0x1 0x0 " tlm_iin_est               ,Result of estimated input current computation based on Iout, Vout, Vin and Duty Cycle values."

; ------------------- TLM_VOUT_DIV_VIN member of telem -------------------

  rgroup 0x0018++0x0003
    line.long 0x000 "TLM_VOUT_DIV_VIN, Result of equation (Vout / Vin) computed during input current estimation."
    textline "                   "
    hexmask.long.word 0x0 0.--11. 0x1 0x0 " tlm_vout_div_vin          ,Result of equation (Vout / Vin) computed during input current estimation."

; --------------------- TLM_IOUT_FS member of telem ---------------------

  rgroup 0x001C++0x0003
    line.long 0x000 "TLM_IOUT_FS, Cycle averged output current updated at Fswitch rate."
    textline "                   "
    hexmask.long.word 0x0 0.--12. 0x1 0x0 " tlm_iout_fs               ,Cycle averged output current updated at Fswitch rate."

; --------------------- TLM_IOUT_FSW member of telem ---------------------

  rgroup 0x0020++0x0003
    line.long 0x000 "TLM_IOUT_FSW, Low pas filtered output current telemetry updated at Fswitch rate PMBus command computed as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--12. 0x1 0x0 " tlm_iout_fsw              ,Low pas filtered output current telemetry updated at Fswitch rate PMBus command computed as follows: "

; -------------------- TLM_VIN_FORCE member of telem --------------------

  group 0x0024++0x0003
    line.long 0x000 "TLM_VIN_FORCE, Forced Vin input value.  Selected as source for Vin by tlm_vin_src_sel."
    textline "                   "
    hexmask.long.word 0x0 0.--10. 0x1 0x0 " tlm_vin_force             ,Forced Vin input value.  Selected as source for Vin by tlm_vin_src_sel."

; ------------------ TLM_VI_CNVRT_FACT member of telem ------------------

  group 0x0028++0x0003
    line.long 0x000 "TLM_VI_CNVRT_FACT, Conversion factor for computing Vin from the measured VS ADC output.  It consists of 3 components: scaling for the Vrect resistor divider, scaling for the tranformer / topology and shifting the binary point from the ADC representation (1.25mV) to 1V. Computed from PMBus commands as follows: "
    textline "                   "
    hexmask.long.long 0x0 0.--21. 0x1 0x0 " tlm_vin_convert_factor    ,Conversion factor for computing Vin from the measured VS ADC output.  It consists of 3 components: scaling for the Vrect resistor divider, scaling for the tranformer / topology and shifting the binary point from the ADC representation (1.25mV) to 1V. Computed from PMBus commands as follows: "

; --------------------- TLM_VIN_LPF member of telem ---------------------

  rgroup 0x002C++0x0003
    line.long 0x000 "TLM_VIN_LPF, Low pass filtered input voltage telemetry. PMBus command computed as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--10. 0x1 0x0 " tlm_vin_lpf               ,Low pass filtered input voltage telemetry. PMBus command computed as follows: "

; ------------------ TLM_VO_CNVRT_FACT member of telem ------------------

  group 0x0030++0x0003
    line.long 0x000 "TLM_VO_CNVRT_FACT, Conversion factor for computing Vout from the measured VS ADC output.  It consists of 2 components: scaling for the Vout resistor divider and shifting the binary point from the ADC representation (1.25mV) to 1V. Computed from PMBus commands as follows: "
    textline "                   "
    hexmask.long.long 0x0 0.--20. 0x1 0x0 " tlm_vout_convert_factor   ,Conversion factor for computing Vout from the measured VS ADC output.  It consists of 2 components: scaling for the Vout resistor divider and shifting the binary point from the ADC representation (1.25mV) to 1V. Computed from PMBus commands as follows: "

; --------------------- TLM_VOUT_FS member of telem ---------------------

  rgroup 0x0034++0x0003
    line.long 0x000 "TLM_VOUT_FS, Output voltage (Vout) telemetry at the sample clock rate (50MHz).  This field is in VS ADC code format (i.e., the voltage at the VSEN pin after the sense resistor divider) and must be scaled by VOUT_SCALE_LOOP for output referenced voltage.  See tlm_vout_fsw description for scale equation."
    textline "                   "
    hexmask.long.word 0x0 0.--11. 0x1 0x0 " tlm_vout_fs               ,Output voltage (Vout) telemetry at the sample clock rate (50MHz).  This field is in VS ADC code format (i.e., the voltage at the VSEN pin after the sense resistor divider) and must be scaled by VOUT_SCALE_LOOP for output referenced voltage.  See tlm_vout_fsw description for scale equation."

; --------------------- TLM_VOUT_FSW member of telem ---------------------

  rgroup 0x0038++0x0003
    line.long 0x000 "TLM_VOUT_FSW, Low pass filtered output voltage (Vout) telemetry updated at the Fswitch clock rate. "
    textline "                   "
    hexmask.long.word 0x0 0.--14. 0x1 0x0 " tlm_vout_fsw              ,Low pass filtered output voltage (Vout) telemetry updated at the Fswitch clock rate. "

; ------------------ TLM_TRNS_SCALE_LP member of telem ------------------

  group 0x003C++0x0003
    line.long 0x000 "TLM_TRNS_SCALE_LP, Ratio of Vrect to Vin.  For Half-Bridge equal to Nturn_sec / (2 * Nturn_pri), otherwise equal to Nturn_sec / Nturn_pri. Computed from PMBus as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--11. 0x1 0x0 " tlm_transformer_scale_lo? ,Ratio of Vrect to Vin.  For Half-Bridge equal to Nturn_sec / (2 * Nturn_pri), otherwise equal to Nturn_sec / Nturn_pri. Computed from PMBus as follows: "

; ----------------- TLM_VRECT_SCALE_LOOP member of telem -----------------

  group 0x0040++0x0003
    line.long 0x000 "TLM_VRECT_SCALE_LO?, Vrect sense resitor scale value. Computed from PMBus as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--11. 0x1 0x0 " tlm_vrect_scale_loop      ,Vrect sense resitor scale value. Computed from PMBus as follows: "

; ----------------- TLM_VOUT_SCALE_LOOP member of telem -----------------

  group 0x0044++0x0003
    line.long 0x000 "TLM_VOUT_SCALE_LOOP, Vout sense resitor scale value Computed from PMBus as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " tlm_vout_scale_loop       ,Vout sense resitor scale value Computed from PMBus as follows: "

; --------------------- TLM_HILO_SEL member of telem ---------------------

  group 0x0048++0x0003
    line.long 0x000 "TLM_HILO_SEL, Input select for Hi/Lo watermark detector A "
    textline "                   "
    hexmask.long.byte 0x0 0.--1. 0x1 0x0 " tlm_hilo_mark_A_sel       ,Input select for Hi/Lo watermark detector A "
    textline "                   "
    hexmask.long.byte 0x0 2.--3. 0x1 0x0 " tlm_hilo_mark_B_sel       ,Input select for Hi/Lo watermark detector B "

; -------------------- TLM_HILO_CLRA member of telem --------------------

  group 0x004C++0x0003
    line.long 0x000 "TLM_HILO_CLRA, Clear for Hi/Lo watermark detector A"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " tlm_hilo_mark_A_clr       ,Clear for Hi/Lo watermark detector A"

; -------------------- TLM_HILO_CLRB member of telem --------------------

  group 0x0050++0x0003
    line.long 0x000 "TLM_HILO_CLRB, Clear for Hi/Lo watermark detector B"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " tlm_hilo_mark_B_clr       ,Clear for Hi/Lo watermark detector B"

; -------------------- TLM_HILO_OUTA member of telem --------------------

  rgroup 0x0054++0x0003
    line.long 0x000 "TLM_HILO_OUTA, High watermark detector A output.  Format depends on input selected by tlm_hilo_mark_A_sel."
    textline "                   "
    hexmask.long.word 0x0 0.--12. 0x1 0x0 " tlm_out_hi_A              ,High watermark detector A output.  Format depends on input selected by tlm_hilo_mark_A_sel."
    textline "                   "
    hexmask.long.word 0x0 13.--25. 0x1 0x0 " tlm_out_lo_A              ,Low watermark detector A output.  Format depends on input selected by tlm_hilo_mark_A_sel."

; -------------------- TLM_HILO_OUTB member of telem --------------------

  rgroup 0x0058++0x0003
    line.long 0x000 "TLM_HILO_OUTB, High watermark detector B output.  Format depends on input selected by tlm_hilo_mark_B_sel."
    textline "                   "
    hexmask.long.word 0x0 0.--12. 0x1 0x0 " tlm_out_hi_B              ,High watermark detector B output.  Format depends on input selected by tlm_hilo_mark_B_sel."
    textline "                   "
    hexmask.long.word 0x0 13.--25. 0x1 0x0 " tlm_out_lo_B              ,Low watermark detector B output.  Format depends on input selected by tlm_hilo_mark_B_sel."

tree.end

; -------------------------------------------------------------------
; End Block - telem
; -------------------------------------------------------------------
tree.end
; @file:      test.per
; Chip name:  SHASTA
; Module:     test
; 
; Generated by the pmm metagen library.
;
; ===================================================================
; Copyright (C) 2018 Infineon Technologies AG
; All rights reserved.
; ===================================================================
;
; ===================================================================
; This document contains proprietary information. Passing on and
; copying of this document, and communication of its contents is not
; permitted without prior written authorisation.
; ===================================================================

; This file is automatically generated. Do not edit!


config 32. 8.
width 20.

tree "Block - test"
; -------------------------------------------------------------------
; Begin Block - test
; -------------------------------------------------------------------
base D:0x70005800

tree "test"
; ----------------------- MP_FORCE member of test -----------------------

  group 0x0000++0x0003
    line.long 0x000 "MP_FORCE, ATE Test Control to force all input capable buffers to be enabled. Note: Places corresponding output buffer in HiZ."
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " force_all_in              ,ATE Test Control to force all input capable buffers to be enabled. Note: Places corresponding output buffer in HiZ."
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " force_all_hi              ,ATE Test Control to force all output capable buffers to output a logic one. Note: Ouput buffers placed in HiZ if both force_all_hi and force_all_lo are asserted."
    textline "                   "
    hexmask.long.byte 0x0 2.--2. 0x1 0x0 " force_all_lo              ,ATE Test Control to force all output capable buffers to output a logic zero. Note: Ouput buffers placed in HiZ if both force_all_hi and force_all_lo are asserted."

; ------------------------ MP_TMUX member of test ------------------------

  group 0x0004++0x0003
    line.long 0x000 "MP_TMUX, Not used"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " debug_sel                 ,Not used"
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " atmux_sel                 ,Enables Analog Test Mux on SMBALERT# and EN pins when high."
    textline "                   "
    hexmask.long.byte 0x0 2.--6. 0x1 0x0 " dtmux_sel                 ,Enable digital test mux output on selected pin when corresponding bit is high. "
    textline "                   "
    hexmask.long.byte 0x0 7.--11. 0x1 0x0 " dtmux_ab_sel              ,Select TMUXB for output on selected pin when corresponding bit is high, otherwise selct TMUXA. "

; ----------------------- TEST_CFG1 member of test -----------------------

  group 0x0008++0x0003
    line.long 0x000 "TEST_CFG1, Bypass all internal low pass filters (e.g., telemetry) when high."
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " bypass_all_filters        ,Bypass all internal low pass filters (e.g., telemetry) when high."
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " test_irq_en               ,Test block interrupts (IRQ) enabled when high."

; ------------------------ SM_TEST member of test ------------------------

  group 0x000C++0x0003
    line.long 0x000 "SM_TEST, Test state control "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " sm_test_mode              ,Test state control "
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " block_en_all              ,Test mode override of block enables.  If both sm_test_mode and block_en_all are high then all enables from common.EN_REG1, common.EN_REG2 and common.EN_REG3 are forced high."

; ----------------------- TEST_TBUS member of test -----------------------

  rgroup 0x0010++0x0003
    line.long 0x000 "TEST_TBUS, Digital test bus (TBUS) status register.  This register contains the output of final tbus mux which is also the input to the Voltage DAC (VDAC)."
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " test_tbus                 ,Digital test bus (TBUS) status register.  This register contains the output of final tbus mux which is also the input to the Voltage DAC (VDAC)."

; ----------------------- TMUX_ANA member of test -----------------------

  group 0x0014++0x0003
    line.long 0x000 "TMUX_ANA, Analog test mux block select.  This register selects which functional block is selected for the analog test mux output. "
    textline "                   "
    hexmask.long.byte 0x0 0.--5. 0x1 0x0 " tmux_blk_ana              ,Analog test mux block select.  This register selects which functional block is selected for the analog test mux output. "
    textline "                   "
    hexmask.long.byte 0x0 6.--11. 0x1 0x0 " tmux_sel_ana              ,Analog test mux input select.  This register selects the analog test mux input within the block selected by tmux_blk_ana."
    textline "                   "
    hexmask.long.byte 0x0 12.--12. 0x1 0x0 " tmux_ana_mode_3v3         ,Analog test mux supply domain select. "

; ------------------------- TBUS member of test -------------------------

  group 0x0018++0x0003
    line.long 0x000 "TBUS, Digital test bus (TBUS) input select.  This register selects the TBUS mux input within the block selected by tbus_blk_sel."
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " tbus_sel                  ,Digital test bus (TBUS) input select.  This register selects the TBUS mux input within the block selected by tbus_blk_sel."
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " tbus_blk_sel              ,Digital test bus (TBUS) block select.  This register selects which functional block is selected for the TBUS output. "

; ------------------------- TMUX member of test -------------------------

  group 0x001C++0x0003
    line.long 0x000 "TMUX, Digital test mux A (TMUXA) input select.  This register selects the TMUXA input within the block selected by tmuxa_blk_sel."
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " tmuxa_sel                 ,Digital test mux A (TMUXA) input select.  This register selects the TMUXA input within the block selected by tmuxa_blk_sel."
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " tmuxa_blk_sel             ,Digital test mux A (TMUXA) block select.  This register selects which functional block is selected for the TMUXA output. "
    textline "                   "
    hexmask.long.byte 0x0 16.--23. 0x1 0x0 " tmuxb_sel                 ,Digital test mux B (TMUXB) input select.  This register selects the TMUXB input within the block selected by tmuxa_blk_sel."
    textline "                   "
    hexmask.long.byte 0x0 24.--31. 0x1 0x0 " tmuxb_blk_sel             ,Digital test mux B (TMUXB) block select.  This register selects which functional block is selected for the TMUXB output. "

; --------------------- TEST_REF_DIG member of test ---------------------

  group 0x0020++0x0003
    line.long 0x000 "TEST_REF_DIG, Voltage DAC (VDAC, a.k.a. MDAC) test mode forced input value."
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " mdac_ref_dig_force_din    ,Voltage DAC (VDAC, a.k.a. MDAC) test mode forced input value."
    textline "                   "
    hexmask.long.word 0x0 8.--19. 0x1 0x0 " ref_dig_target            ,Voltage DAC (VDAC, a.k.a. MDAC) DNL BIST target value."
    textline "                   "
    hexmask.long.byte 0x0 20.--20. 0x1 0x0 " mdac_ref_dig_ramp_sel     ,Voltage DAC (VDAC, a.k.a. MDAC)  data source select "
    textline "                   "
    hexmask.long.byte 0x0 21.--21. 0x1 0x0 " mdac_ref_dig_force_en     ,Voltage DAC (VDAC, a.k.a. MDAC) test mode force enable. "

; ---------------------- TEST_TSADC0 member of test ----------------------

  group 0x0024++0x0003
    line.long 0x000 "TEST_TSADC0, TS ADC BIST expected offset value."
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " ts_test_tsadc_offs_expec? ,TS ADC BIST expected offset value."
    textline "                   "
    hexmask.long.byte 0x0 8.--14. 0x1 0x0 " ts_test_tsadc_gain_limit  ,TS ADC BIST gain error limit."
    textline "                   "
    hexmask.long.byte 0x0 15.--21. 0x1 0x0 " ts_test_tsadc_offs_limit  ,TS ADC BIST offset error limit."

; ---------------------- TEST_TSADC1 member of test ----------------------

  group 0x0028++0x0003
    line.long 0x000 "TEST_TSADC1, TS ADC DNL BIST number of samples averaged "
    textline "                   "
    hexmask.long.byte 0x0 0.--2. 0x1 0x0 " ts_test_tsadc_dnl_avg_len ,TS ADC DNL BIST number of samples averaged "
    textline "                   "
    hexmask.long.byte 0x0 3.--5. 0x1 0x0 " ts_test_tsadc_gain_avg_l? ,TS ADC Gain BIST number of samples averaged "
    textline "                   "
    hexmask.long.byte 0x0 6.--8. 0x1 0x0 " ts_test_tsidac_dnl_avg_l? ,TS Current DAC DNL BIST number of samples averaged "
    textline "                   "
    hexmask.long.byte 0x0 9.--11. 0x1 0x0 " ts_test_tsadc_offs_avg_l? ,TS ADC Offset BIST number of samples averaged "
    textline "                   "
    hexmask.long.byte 0x0 12.--15. 0x1 0x0 " ts_test_tsidac_dnl_limit  ,TS Current DAC BIST DNL error limit."
    textline "                   "
    hexmask.long.byte 0x0 16.--19. 0x1 0x0 " ts_test_tsadc_dnl_limit   ,TS ADC BIST DNL error limit."

; ---------------------- TEST_TSADC2 member of test ----------------------

  group 0x002C++0x0003
    line.long 0x000 "TEST_TSADC2, TS ADC input short control for DNL and offset BIST. "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " ts_test_tsadc_az          ,TS ADC input short control for DNL and offset BIST. "
    textline "                   "
    hexmask.long.byte 0x0 1.--4. 0x1 0x0 " ts_tsadc_meas_sel         ,Not used"
    textline "                   "
    hexmask.long.byte 0x0 5.--9. 0x1 0x0 " ts_test_mode              ,TS ADC / IDAC test mode control "
    textline "                   "
    hexmask.long.byte 0x0 10.--10. 0x1 0x0 " ts_test_p1p2_sel          ,TS ADC gain calibration testpoint select. "
    textline "                   "
    hexmask.long.byte 0x0 11.--11. 0x1 0x0 " ts_test_tsadc_en          ,Not used"
    textline "                   "
    hexmask.long.byte 0x0 12.--19. 0x1 0x0 " ts_test_tsadc_dnl_mask    ,Individual mask bit for vs_dac = 64, 48, 32, 16, 8, 4, 2, 1 during DNL measurement"
    textline "                   "
    hexmask.long.byte 0x0 20.--27. 0x1 0x0 " ts_test_tsadc_gain_expec? ,TS ADC Gain BIST expected value."

; ---------------------- TEST_TSIDAC member of test ----------------------

  group 0x0030++0x0003
    line.long 0x000 "TEST_TSIDAC, TS Current DAC BIST enable "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " ts_test_tsidac_en         ,TS Current DAC BIST enable "

; ----------------------- TEST_IS0 member of test -----------------------

  group 0x0034++0x0003
    line.long 0x000 "TEST_IS0, IS ADC Offset BIST expected value."
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " is_test_offs_expected     ,IS ADC Offset BIST expected value."
    textline "                   "
    hexmask.long.byte 0x0 8.--14. 0x1 0x0 " is_test_gain_limit        ,IS ADC BIST gain error limit."
    textline "                   "
    hexmask.long.byte 0x0 15.--20. 0x1 0x0 " is_test_offs_limit        ,IS ADC BIST offset error limit."

; ----------------------- TEST_IS1 member of test -----------------------

  group 0x0038++0x0003
    line.long 0x000 "TEST_IS1, IS ADC Gain BIST number of samples averaged "
    textline "                   "
    hexmask.long.byte 0x0 0.--2. 0x1 0x0 " is_test_gain_avg_len      ,IS ADC Gain BIST number of samples averaged "
    textline "                   "
    hexmask.long.byte 0x0 3.--5. 0x1 0x0 " is_test_dnl_avg_len       ,IS ADC DNL BIST number of samples averaged "
    textline "                   "
    hexmask.long.byte 0x0 6.--8. 0x1 0x0 " is_test_offs_avg_len      ,IS ADC Offset BIST number of samples averaged "
    textline "                   "
    hexmask.long.byte 0x0 9.--11. 0x1 0x0 " is_test_dnl_limit         ,IS ADC BIST DNL error limit."
    textline "                   "
    hexmask.long.byte 0x0 12.--15. 0x1 0x0 " is_test_comp_limit        ,IS ADC Comparator BIST error limit."
    textline "                   "
    hexmask.long.byte 0x0 16.--20. 0x1 0x0 " is_test_comp_expected     ,IS ADC Comparator BIST expected value."

; ----------------------- TEST_IS2 member of test -----------------------

  group 0x003C++0x0003
    line.long 0x000 "TEST_IS2, IS ADC Comparator BIST comparator select. "
    textline "                   "
    hexmask.long.byte 0x0 0.--2. 0x1 0x0 " is_test_comp_sel_ib       ,IS ADC Comparator BIST comparator select. "
    textline "                   "
    hexmask.long.byte 0x0 3.--4. 0x1 0x0 " is_test_comp_en           ,IS ADC Comparator BIST enable / mode select "
    textline "                   "
    hexmask.long.byte 0x0 5.--8. 0x1 0x0 " is_test_mode              ,IS ADC test mode control. "
    textline "                   "
    hexmask.long.byte 0x0 9.--9. 0x1 0x0 " is_test_dac_en            ,IS DAC Source Select "
    textline "                   "
    hexmask.long.byte 0x0 10.--10. 0x1 0x0 " is_auto_cal_en            ,No longer used, set to 0."
    textline "                   "
    hexmask.long.byte 0x0 11.--12. 0x1 0x0 " is_test_isen_src_sel      ,IS Test Mode IS2 (calibration IS) source select "
    textline "                   "
    hexmask.long.byte 0x0 13.--20. 0x1 0x0 " is_test_dnl_mask          ,IS ADC Individual mask bit for is_dac = 96, 64, 32, 16, 8, 4, 2, 1 during DNL measurement"
    textline "                   "
    hexmask.long.byte 0x0 21.--28. 0x1 0x0 " is_test_gain_expected     ,IS ADC Gain BIST expected value."

; ----------------------- TEST_IS3 member of test -----------------------

  group 0x0040++0x0003
    line.long 0x000 "TEST_IS3, Engineering evaluation control bits for IS block characterization."
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " is_test_eec               ,Engineering evaluation control bits for IS block characterization."
    textline "                   "
    hexmask.long.byte 0x0 8.--8. 0x1 0x0 " is_test_step_en           ,IS / TS ADC DNL BIST tracking loop step-size select. "
    textline "                   "
    hexmask.long.byte 0x0 9.--12. 0x1 0x0 " is_test_step              ,IS / TS ADC DNL BIST tracking loop step-size."

; ----------------------- TEST_VS0 member of test -----------------------

  group 0x0044++0x0003
    line.long 0x000 "TEST_VS0, VS ADC Offset BIST expected value."
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " vs_test_offs_expected     ,VS ADC Offset BIST expected value."
    textline "                   "
    hexmask.long.byte 0x0 8.--14. 0x1 0x0 " vs_test_gain_limit        ,VS ADC Gain BIST error limit."
    textline "                   "
    hexmask.long.byte 0x0 15.--21. 0x1 0x0 " vs_test_offs_limit        ,VS ADC Offset BIST error limit."
    textline "                   "
    hexmask.long.byte 0x0 22.--24. 0x1 0x0 " vs_test_dnl_avg_len       ,VS ADC DNL BIST number of samples averaged "
    textline "                   "
    hexmask.long.byte 0x0 25.--27. 0x1 0x0 " vs_test_gain_avg_len      ,VS ADC Gain BIST number of samples averaged "
    textline "                   "
    hexmask.long.byte 0x0 28.--30. 0x1 0x0 " vs_test_offs_avg_len      ,VS ADC Offset BIST number of samples averaged "

; ----------------------- TEST_VS1 member of test -----------------------

  group 0x0048++0x0003
    line.long 0x000 "TEST_VS1, VS ADC Gain BIST expected value."
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " vs_test_gain_expected     ,VS ADC Gain BIST expected value."
    textline "                   "
    hexmask.long.byte 0x0 8.--10. 0x1 0x0 " vs_test_dnl_limit         ,VS ADC DNL BIST error limit."
    textline "                   "
    hexmask.long.byte 0x0 11.--14. 0x1 0x0 " vs_test_mode              ,VS ADC test mode control. "
    textline "                   "
    hexmask.long.byte 0x0 15.--15. 0x1 0x0 " vs_test_p1p2_sel          ,VS ADC gain calibration testpoint select. "
    textline "                   "
    hexmask.long.byte 0x0 16.--16. 0x1 0x0 " vs_test_dac_en            ,VS DAC Source Select "
    textline "                   "
    hexmask.long.byte 0x0 17.--24. 0x1 0x0 " vs_test_dnl_mask          ,Individual mask bit for vs_dac = 96, 64, 32, 16, 8, 4, 2, 1 during DNL measurement"
    textline "                   "
    hexmask.long.byte 0x0 25.--27. 0x1 0x0 " vs_test_stress_avg_len    ,VS ADC Stress Compensation BIST number of samples averaged "

; --------------------- TEST_RAMP_GEN member of test ---------------------

  group 0x004C++0x0003
    line.long 0x000 "TEST_RAMP_GEN, BIST DAC ramp minimum count."
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " ramp_gen_min_cnt          ,BIST DAC ramp minimum count."
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " ramp_gen_max_cnt          ,BIST DAC ramp maximum count."
    textline "                   "
    hexmask.long.word 0x0 16.--25. 0x1 0x0 " ramp_gen_dwell_cnt        ,BIST DAC ramp dwell time.  Defines the time spent at each step in the ramp."
    textline "                   "
    hexmask.long.byte 0x0 26.--26. 0x1 0x0 " ramp_gen_type             ,BIST DAC ramp generator waveform shape select. "
    textline "                   "
    hexmask.long.byte 0x0 27.--27. 0x1 0x0 " ramp_gen_start_mode       ,BIST DAC ramp generator start mode select. "
    textline "                   "
    hexmask.long.byte 0x0 28.--28. 0x1 0x0 " ramp_gen_start            ,BIST DAC ramp generator start signal.  When selected via ramp_gen_start_mode, this register enables or disables the ramp generator. "
    textline "                   "
    hexmask.long.byte 0x0 29.--29. 0x1 0x0 " ramp_gen_one_shot         ,BIST DAC ramp generator clock source select "
    textline "                   "
    hexmask.long.byte 0x0 30.--30. 0x1 0x0 " ramp_gen_arm              ,BIST DAC ramp generation arm counter signal "

; --------------------- TEST_RAMP_DLY member of test ---------------------

  group 0x0050++0x0003
    line.long 0x000 "TEST_RAMP_DLY, IS, VS, TS BIST start-of measurement delay time"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " ramp_dly_time             ,IS, VS, TS BIST start-of measurement delay time"

; --------------------- TEST_LO_CLK1 member of test ---------------------

  group 0x0054++0x0003
    line.long 0x000 "TEST_LO_CLK1, LO Clock BIST trim code error limit."
    textline "                   "
    hexmask.long.byte 0x0 0.--6. 0x1 0x0 " lo_clk_trim_err_limit     ,LO Clock BIST trim code error limit."

; --------------------- TEST_LO_CLK2 member of test ---------------------

  group 0x0058++0x0003
    line.long 0x000 "TEST_LO_CLK2, LO Clock BIST (200MHz mode) trim error measurement enable.  When enabled, the BIST will measure the LO Clock trim error. "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " lo_clk_meas_en            ,LO Clock BIST (200MHz mode) trim error measurement enable.  When enabled, the BIST will measure the LO Clock trim error. "
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " lo_clk_trim_en            ,LO Clock BIST (200MHz mode) enable control.  When enabled, the BIST function will self trim the LO Clock. "
    textline "                   "
    hexmask.long.byte 0x0 2.--2. 0x1 0x0 " lo_clk_20mhz_meas_en      ,LO Clock BIST (20MHz mode) trim error measurement enable.  When enabled, the BIST will measure the LO Clock trim error. "
    textline "                   "
    hexmask.long.byte 0x0 3.--3. 0x1 0x0 " lo_clk_20mhz_trim_en      ,LO Clock BIST (20MHz mode) enable control.  When enabled, the BIST function will self trim the LO Clock. "

; ---------------------- TEST_CONFIG member of test ----------------------

  group 0x005C++0x0003
    line.long 0x000 "TEST_CONFIG, DNL BIST status select.  Selects reported value for DNL BIST on VS, IS and TS. "
    textline "                   "
    hexmask.long.byte 0x0 0.--1. 0x1 0x0 " dnl_mux                   ,DNL BIST status select.  Selects reported value for DNL BIST on VS, IS and TS. "
    textline "                   "
    hexmask.long.byte 0x0 2.--5. 0x1 0x0 " test_step                 ,Not used"
    textline "                   "
    hexmask.long.byte 0x0 6.--6. 0x1 0x0 " test_step_en              ,Not used"
    textline "                   "
    hexmask.long.byte 0x0 7.--7. 0x1 0x0 " iadc_src_sel              ,Not used"

; ------------------------ TSEN_XV member of test ------------------------

  group 0x0060++0x0003
    line.long 0x000 "TSEN_XV, X-Valent Config (XADDR) test mode control "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " xv_config_test_en         ,X-Valent Config (XADDR) test mode control "
    textline "                   "
    hexmask.long.byte 0x0 1.--2. 0x1 0x0 " xv_inmux_test_sel         ,X-Valent Config (XADDR) test mode source select "

; ----------------------- TEST_GATE member of test -----------------------

  group 0x0064++0x0003
    line.long 0x000 "TEST_GATE, When high, overrides (disables) the XADDR1 test gate input latch."
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " test_gate_kill_switch     ,When high, overrides (disables) the XADDR1 test gate input latch."

tree.end

; -------------------------------------------------------------------
; End Block - test
; -------------------------------------------------------------------
tree.end
; @file:      teststat.per
; Chip name:  SHASTA
; Module:     teststat
; 
; Generated by the pmm metagen library.
;
; ===================================================================
; Copyright (C) 2018 Infineon Technologies AG
; All rights reserved.
; ===================================================================
;
; ===================================================================
; This document contains proprietary information. Passing on and
; copying of this document, and communication of its contents is not
; permitted without prior written authorisation.
; ===================================================================

; This file is automatically generated. Do not edit!


config 32. 8.
width 20.

tree "Block - teststat"
; -------------------------------------------------------------------
; Begin Block - teststat
; -------------------------------------------------------------------
base D:0x70005C00

tree "teststat"
; --------------------- BIST_AVG1 member of teststat ---------------------

  rgroup 0x0000++0x0003
    line.long 0x000 "BIST_AVG1, TBD"
    textline "                   "
    hexmask.long.word 0x0 0.--13. 0x1 0x0 " iadc_ch1_avg              ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 14.--14. 0x1 0x0 " iadc_ch1_avg_valid        ,TBD"
    textline "                   "
    hexmask.long.word 0x0 15.--28. 0x1 0x0 " iadc_ch2_avg              ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 29.--29. 0x1 0x0 " iadc_ch2_avg_valid        ,TBD"

; --------------------- BIST_AVG2 member of teststat ---------------------

  rgroup 0x0004++0x0003
    line.long 0x000 "BIST_AVG2, TBD"
    textline "                   "
    hexmask.long.word 0x0 0.--13. 0x1 0x0 " iadc_ch3_avg              ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 14.--14. 0x1 0x0 " iadc_ch3_avg_valid        ,TBD"
    textline "                   "
    hexmask.long.word 0x0 15.--29. 0x1 0x0 " tadc_avg                  ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 30.--30. 0x1 0x0 " tadc_avg_valid            ,TBD"

; --------------------- BIST_AVG3 member of teststat ---------------------

  rgroup 0x0008++0x0003
    line.long 0x000 "BIST_AVG3, TBD"
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " vadc_ch0_avg              ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 16.--23. 0x1 0x0 " vs0_os_trim_avg           ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 24.--30. 0x1 0x0 " vs0_os_trim_tm            ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 31.--31. 0x1 0x0 " vadc_ch0_avg_valid        ,TBD"

; --------------------- BIST_AVG4 member of teststat ---------------------

  rgroup 0x000C++0x0003
    line.long 0x000 "BIST_AVG4, TBD"
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " vadc_ch1_avg              ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 16.--23. 0x1 0x0 " vs1_os_trim_avg           ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 24.--30. 0x1 0x0 " vs1_os_trim_tm            ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 31.--31. 0x1 0x0 " vadc_ch1_avg_valid        ,TBD"

; --------------------- BIST_AVG5 member of teststat ---------------------

  rgroup 0x0010++0x0003
    line.long 0x000 "BIST_AVG5, TBD"
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " vadc_ch2_avg              ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 16.--23. 0x1 0x0 " vs2_os_trim_avg           ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 24.--30. 0x1 0x0 " vs2_os_trim_tm            ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 31.--31. 0x1 0x0 " vadc_ch2_avg_valid        ,TBD"

; --------------------- BIST_LO1 member of teststat ---------------------

  rgroup 0x0014++0x0003
    line.long 0x000 "BIST_LO1, TBD"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " lo_clk_20mhz_err_avg      ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 8.--8. 0x1 0x0 " lo_clk_20mhz_err_avg_val? ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 9.--15. 0x1 0x0 " lo_clk_20mhz_trim_coarse? ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 16.--16. 0x1 0x0 " lo_clk_20mhz_trim_coarse? ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 17.--17. 0x1 0x0 " lo_clk_20mhz_trim_comple? ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 18.--18. 0x1 0x0 " lo_clk_20mhz_trim_err     ,TBD"

; --------------------- BIST_LO2 member of teststat ---------------------

  rgroup 0x0018++0x0003
    line.long 0x000 "BIST_LO2, TBD"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " lo_clk_err_avg            ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 8.--8. 0x1 0x0 " lo_clk_err_avg_valid      ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 9.--15. 0x1 0x0 " lo_clk_trim_coarse_bist   ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 16.--16. 0x1 0x0 " lo_clk_trim_coarse_ovr    ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 17.--17. 0x1 0x0 " lo_clk_trim_complete      ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 18.--18. 0x1 0x0 " lo_clk_trim_err           ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 19.--23. 0x1 0x0 " lo_clk_trim_fine_bist     ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 24.--24. 0x1 0x0 " lo_clk_trim_fine_ovr      ,TBD"

; ------------------- BIST_IS_COMP member of teststat -------------------

  rgroup 0x001C++0x0003
    line.long 0x000 "BIST_IS_COMP, TBD"
    textline "                   "
    hexmask.long.word 0x0 0.--8. 0x1 0x0 " is1_test_comp             ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 9.--9. 0x1 0x0 " is1_test_comp_err         ,TBD"
    textline "                   "
    hexmask.long.word 0x0 10.--18. 0x1 0x0 " is2_test_comp             ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 19.--19. 0x1 0x0 " is2_test_comp_err         ,TBD"
    textline "                   "
    hexmask.long.word 0x0 20.--28. 0x1 0x0 " is3_test_comp             ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 29.--29. 0x1 0x0 " is3_test_comp_err         ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 30.--30. 0x1 0x0 " is_test_comp_complete     ,TBD"

; -------------------- BIST_IS_DNL member of teststat --------------------

  rgroup 0x0020++0x0003
    line.long 0x000 "BIST_IS_DNL, TBD"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " is1_test_dnl              ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 8.--8. 0x1 0x0 " is1_test_dnl_err          ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 9.--16. 0x1 0x0 " is2_test_dnl              ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 17.--17. 0x1 0x0 " is2_test_dnl_err          ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 18.--25. 0x1 0x0 " is3_test_dnl              ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 26.--26. 0x1 0x0 " is3_test_dnl_err          ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 27.--27. 0x1 0x0 " is_test_dnl_complete      ,TBD"

; ------------------- BIST_IS_GAIN member of teststat -------------------

  rgroup 0x0024++0x0003
    line.long 0x000 "BIST_IS_GAIN, TBD"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " is1_test_gain_comp        ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 8.--8. 0x1 0x0 " is1_test_gain_err         ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 9.--16. 0x1 0x0 " is2_test_gain_comp        ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 17.--17. 0x1 0x0 " is2_test_gain_err         ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 18.--25. 0x1 0x0 " is3_test_gain_comp        ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 26.--26. 0x1 0x0 " is3_test_gain_err         ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 27.--27. 0x1 0x0 " is_test_gain_complete     ,TBD"

; ------------------- BIST_IS_OFF1 member of teststat -------------------

  rgroup 0x0028++0x0003
    line.long 0x000 "BIST_IS_OFF1, TBD"
    textline "                   "
    hexmask.long.word 0x0 0.--9. 0x1 0x0 " is1_test_offs             ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 10.--10. 0x1 0x0 " is1_test_offs_err         ,TBD"
    textline "                   "
    hexmask.long.word 0x0 11.--20. 0x1 0x0 " is2_test_offs             ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 21.--21. 0x1 0x0 " is2_test_offs_err         ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 22.--22. 0x1 0x0 " is_test_offs_complete     ,TBD"

; ------------------- BIST_IS_OFF2 member of teststat -------------------

  rgroup 0x002C++0x0003
    line.long 0x000 "BIST_IS_OFF2, TBD"
    textline "                   "
    hexmask.long.word 0x0 0.--9. 0x1 0x0 " is3_test_offs             ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 10.--10. 0x1 0x0 " is3_test_offs_err         ,TBD"

; -------------------- BIST_TSADC member of teststat --------------------

  rgroup 0x0030++0x0003
    line.long 0x000 "BIST_TSADC, TBD"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " ts_test_tsadc_dnl         ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 8.--8. 0x1 0x0 " ts_test_tsadc_dnl_err     ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 9.--9. 0x1 0x0 " ts_test_tsadc_dnl_comple? ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 10.--17. 0x1 0x0 " ts_test_tsadc_gain_comp   ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 18.--18. 0x1 0x0 " ts_test_tsadc_gain_err    ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 19.--19. 0x1 0x0 " ts_test_tsadc_gain_compl? ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 20.--27. 0x1 0x0 " ts_test_tsadc_offs        ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 28.--28. 0x1 0x0 " ts_test_tsadc_offs_err    ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 29.--29. 0x1 0x0 " ts_test_tsadc_offs_compl? ,TBD"

; -------------------- BIST_TSIDAC member of teststat --------------------

  rgroup 0x0034++0x0003
    line.long 0x000 "BIST_TSIDAC, TBD"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " ts_test_tsidac_dnl        ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 8.--8. 0x1 0x0 " ts_test_tsidac_dnl_err    ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 9.--9. 0x1 0x0 " ts_test_tsidac_dnl_compl? ,TBD"

; -------------------- BIST_VS_DNL member of teststat --------------------

  rgroup 0x0038++0x0003
    line.long 0x000 "BIST_VS_DNL, TBD"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " vs0_test_dnl              ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 8.--8. 0x1 0x0 " vs0_test_dnl_err          ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 9.--16. 0x1 0x0 " vs1_test_dnl              ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 17.--17. 0x1 0x0 " vs1_test_dnl_err          ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 18.--25. 0x1 0x0 " vs2_test_dnl              ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 26.--26. 0x1 0x0 " vs2_test_dnl_err          ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 27.--27. 0x1 0x0 " vs_test_dnl_complete      ,TBD"

; ------------------- BIST_VS_GAIN member of teststat -------------------

  rgroup 0x003C++0x0003
    line.long 0x000 "BIST_VS_GAIN, TBD"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " vs0_test_gain_comp        ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 8.--8. 0x1 0x0 " vs0_test_gain_err         ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 9.--16. 0x1 0x0 " vs1_test_gain_comp        ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 17.--17. 0x1 0x0 " vs1_test_gain_err         ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 18.--25. 0x1 0x0 " vs2_test_gain_comp        ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 26.--26. 0x1 0x0 " vs2_test_gain_err         ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 27.--27. 0x1 0x0 " vs_test_gain_complete     ,TBD"

; ------------------- BIST_VS_OFFS member of teststat -------------------

  rgroup 0x0040++0x0003
    line.long 0x000 "BIST_VS_OFFS, TBD"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " vs0_test_offs             ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 8.--8. 0x1 0x0 " vs0_test_offs_err         ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 9.--16. 0x1 0x0 " vs1_test_offs             ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 17.--17. 0x1 0x0 " vs1_test_offs_err         ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 18.--25. 0x1 0x0 " vs2_test_offs             ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 26.--26. 0x1 0x0 " vs2_test_offs_err         ,TBD"
    textline "                   "
    hexmask.long.byte 0x0 27.--27. 0x1 0x0 " vs_test_offs_complete     ,TBD"

; -------------------- TSADC_COMP1 member of teststat --------------------

  rgroup 0x0044++0x0003
    line.long 0x000 "TSADC_COMP1, TBD"
    textline "                   "
    hexmask.long.word 0x0 0.--14. 0x1 0x0 " ts_atsen_adc_comp         ,TBD"
    textline "                   "
    hexmask.long.word 0x0 15.--29. 0x1 0x0 " ts_btsen_adc_comp         ,TBD"

; -------------------- TSADC_COMP2 member of teststat --------------------

  rgroup 0x0048++0x0003
    line.long 0x000 "TSADC_COMP2, TBD"
    textline "                   "
    hexmask.long.word 0x0 0.--14. 0x1 0x0 " ts_itsen_adc_comp         ,TBD"
    textline "                   "
    hexmask.long.word 0x0 15.--29. 0x1 0x0 " ts_imon_adc_comp          ,TBD"

; -------------------- TSADC_COMP3 member of teststat --------------------

  rgroup 0x004C++0x0003
    line.long 0x000 "TSADC_COMP3, TBD"
    textline "                   "
    hexmask.long.word 0x0 0.--14. 0x1 0x0 " ts_prisen_adc_comp        ,TBD"
    textline "                   "
    hexmask.long.word 0x0 15.--29. 0x1 0x0 " ts_xv1_adc_comp           ,TBD"

; -------------------- TSADC_COMP4 member of teststat --------------------

  rgroup 0x0050++0x0003
    line.long 0x000 "TSADC_COMP4, TBD"
    textline "                   "
    hexmask.long.word 0x0 0.--14. 0x1 0x0 " ts_xv2_adc_comp           ,TBD"

; ------------------- BIST_VS0_FE0 member of teststat -------------------

  rgroup 0x0054++0x0003
    line.long 0x000 "BIST_VS0_FE0, voltage sense 0 - test mode vsadc measurement @ 00h vs_fe_dac  code"
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " vs0_test_stress0          ,voltage sense 0 - test mode vsadc measurement @ 00h vs_fe_dac  code"
    textline "                   "
    hexmask.long.byte 0x0 16.--16. 0x1 0x0 " vs_test_stress_complete   ,voltage sense0,1,2 - test mode vsadc measurement of all three voltage senses are complete"

; ------------------- BIST_VS0_FE12 member of teststat -------------------

  rgroup 0x0058++0x0003
    line.long 0x000 "BIST_VS0_FE12, voltage sense 0 - test mode vsadc measurement @ 01h vs_fe_dac  code"
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " vs0_test_stress1          ,voltage sense 0 - test mode vsadc measurement @ 01h vs_fe_dac  code"
    textline "                   "
    hexmask.long.word 0x0 16.--31. 0x1 0x0 " vs0_test_stress2          ,voltage sense 0 - test mode vsadc measurement @ 02h vs_fe_dac  code"

; ------------------- BIST_VS0_FE34 member of teststat -------------------

  rgroup 0x005C++0x0003
    line.long 0x000 "BIST_VS0_FE34, voltage sense 0 - test mode vsadc measurement @ 04h vs_fe_dac  code"
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " vs0_test_stress3          ,voltage sense 0 - test mode vsadc measurement @ 04h vs_fe_dac  code"
    textline "                   "
    hexmask.long.word 0x0 16.--31. 0x1 0x0 " vs0_test_stress4          ,voltage sense 0 - test mode vsadc measurement @ 08h vs_fe_dac  code"

; ------------------- BIST_VS0_FE56 member of teststat -------------------

  rgroup 0x0060++0x0003
    line.long 0x000 "BIST_VS0_FE56, voltage sense 0 - test mode vsadc measurement @ 10h vs_fe_dac  code"
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " vs0_test_stress5          ,voltage sense 0 - test mode vsadc measurement @ 10h vs_fe_dac  code"
    textline "                   "
    hexmask.long.word 0x0 16.--31. 0x1 0x0 " vs0_test_stress6          ,voltage sense 0 - test mode vsadc measurement @ 20h vs_fe_dac  code"

; ------------------- BIST_VS1_FE0 member of teststat -------------------

  rgroup 0x0064++0x0003
    line.long 0x000 "BIST_VS1_FE0, voltage sense 1 - test mode vsadc measurement @ 00h vs_fe_dac  code"
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " vs1_test_stress0          ,voltage sense 1 - test mode vsadc measurement @ 00h vs_fe_dac  code"

; ------------------- BIST_VS1_FE12 member of teststat -------------------

  rgroup 0x0068++0x0003
    line.long 0x000 "BIST_VS1_FE12, voltage sense 1 - test mode vsadc measurement @ 01h vs_fe_dac  code"
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " vs1_test_stress1          ,voltage sense 1 - test mode vsadc measurement @ 01h vs_fe_dac  code"
    textline "                   "
    hexmask.long.word 0x0 16.--31. 0x1 0x0 " vs1_test_stress2          ,voltage sense 1 - test mode vsadc measurement @ 02h vs_fe_dac  code"

; ------------------- BIST_VS1_FE34 member of teststat -------------------

  rgroup 0x006C++0x0003
    line.long 0x000 "BIST_VS1_FE34, voltage sense 1 - test mode vsadc measurement @ 04h vs_fe_dac  code"
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " vs1_test_stress3          ,voltage sense 1 - test mode vsadc measurement @ 04h vs_fe_dac  code"
    textline "                   "
    hexmask.long.word 0x0 16.--31. 0x1 0x0 " vs1_test_stress4          ,voltage sense 1 - test mode vsadc measurement @ 08h vs_fe_dac  code"

; ------------------- BIST_VS1_FE56 member of teststat -------------------

  rgroup 0x0070++0x0003
    line.long 0x000 "BIST_VS1_FE56, voltage sense 1 - test mode vsadc measurement @ 10h vs_fe_dac  code"
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " vs1_test_stress5          ,voltage sense 1 - test mode vsadc measurement @ 10h vs_fe_dac  code"
    textline "                   "
    hexmask.long.word 0x0 16.--31. 0x1 0x0 " vs1_test_stress6          ,voltage sense 1 - test mode vsadc measurement @ 20h vs_fe_dac  code"

; ------------------- BIST_VS2_FE0 member of teststat -------------------

  rgroup 0x0074++0x0003
    line.long 0x000 "BIST_VS2_FE0, voltage sense 2 - test mode vsadc measurement @ 00h vs_fe_dac  code"
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " vs2_test_stress0          ,voltage sense 2 - test mode vsadc measurement @ 00h vs_fe_dac  code"

; ------------------- BIST_VS2_FE12 member of teststat -------------------

  rgroup 0x0078++0x0003
    line.long 0x000 "BIST_VS2_FE12, voltage sense 2 - test mode vsadc measurement @ 01h vs_fe_dac  code"
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " vs2_test_stress1          ,voltage sense 2 - test mode vsadc measurement @ 01h vs_fe_dac  code"
    textline "                   "
    hexmask.long.word 0x0 16.--31. 0x1 0x0 " vs2_test_stress2          ,voltage sense 2 - test mode vsadc measurement @ 02h vs_fe_dac  code"

; ------------------- BIST_VS2_FE34 member of teststat -------------------

  rgroup 0x007C++0x0003
    line.long 0x000 "BIST_VS2_FE34, voltage sense 2 - test mode vsadc measurement @ 04h vs_fe_dac  code"
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " vs2_test_stress3          ,voltage sense 2 - test mode vsadc measurement @ 04h vs_fe_dac  code"
    textline "                   "
    hexmask.long.word 0x0 16.--31. 0x1 0x0 " vs2_test_stress4          ,voltage sense 2 - test mode vsadc measurement @ 08h vs_fe_dac  code"

; ------------------- BIST_VS2_FE56 member of teststat -------------------

  rgroup 0x0080++0x0003
    line.long 0x000 "BIST_VS2_FE56, voltage sense 2 - test mode vsadc measurement @ 10h vs_fe_dac  code"
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " vs2_test_stress5          ,voltage sense 2 - test mode vsadc measurement @ 10h vs_fe_dac  code"
    textline "                   "
    hexmask.long.word 0x0 16.--31. 0x1 0x0 " vs2_test_stress6          ,voltage sense 2 - test mode vsadc measurement @ 20h vs_fe_dac  code"

; -------------------- BIST_CMPLT member of teststat --------------------

  rgroup 0x0084++0x0003
    line.long 0x000 "BIST_CMPLT, Analog BIST complete when bit high "
    textline "                   "
    hexmask.long.word 0x0 0.--13. 0x1 0x0 " bist_complete             ,Analog BIST complete when bit high "

tree.end

; -------------------------------------------------------------------
; End Block - teststat
; -------------------------------------------------------------------
tree.end
; @file:      tlmcom.per
; Chip name:  SHASTA
; Module:     tlmcom
; 
; Generated by the pmm metagen library.
;
; ===================================================================
; Copyright (C) 2018 Infineon Technologies AG
; All rights reserved.
; ===================================================================
;
; ===================================================================
; This document contains proprietary information. Passing on and
; copying of this document, and communication of its contents is not
; permitted without prior written authorisation.
; ===================================================================

; This file is automatically generated. Do not edit!


config 32. 8.
width 20.

tree "Block - tlmcom"
; -------------------------------------------------------------------
; Begin Block - tlmcom
; -------------------------------------------------------------------
base D:0x70005000

tree "tlmcom"
; ----------------------- TLM_KFP member of tlmcom -----------------------

  group 0x0000++0x0003
    line.long 0x000 "TLM_KFP, ATSEN, BTSEN and ITSEN telemetry LPF coefficient index.  Note that exp settings greater than 9 are clamped to 9.  Set to 63 to bypass filter. "
    textline "                   "
    hexmask.long.byte 0x0 0.--5. 0x1 0x0 " tlm_kfp_tsen              ,ATSEN, BTSEN and ITSEN telemetry LPF coefficient index.  Note that exp settings greater than 9 are clamped to 9.  Set to 63 to bypass filter. "
    textline "                   "
    hexmask.long.byte 0x0 6.--11. 0x1 0x0 " tlm_kfp_prisen            ,PRISEN telemetry LPF coefficient index when used as a general purpose ADC.  Note that exp settings greater than 9 are clamped to 9.  Set to 63 to bypass filter. "
    textline "                   "
    hexmask.long.byte 0x0 12.--17. 0x1 0x0 " tlm_kfp_imon              ,IMON telemetry LPF coefficient index when used as a general purpose ADC.  Note that exp settings greater than 9 are clamped to 9.  Set to 63 to bypass filter. "
    textline "                   "
    hexmask.long.byte 0x0 18.--23. 0x1 0x0 " tlm_kfp_xaddr             ,XADDR1,2 telemetry LPF coefficient index when used as a general purpose ADC.  Note that exp settings greater than 9 are clamped to 9.  Set to 63 to bypass filter. "

; -------------------- TLM_IRQ_THR_0 member of tlmcom --------------------

  group 0x0004++0x0003
    line.long 0x000 "TLM_IRQ_THR_0, Telemetry interrupt (IRQ) 0 threshold.  Compared against signal selected by tlm_irq_thr_src_sel_0."
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " tlm_irq_gereric_thr_0     ,Telemetry interrupt (IRQ) 0 threshold.  Compared against signal selected by tlm_irq_thr_src_sel_0."
    textline "                   "
    hexmask.long.byte 0x0 16.--20. 0x1 0x0 " tlm_irq_thr_src_sel_0     ,Telemetry interrupt (IRQ) 0 source select.  Selects signal to compare agains tlm_irq_gereric_thr_0 for IRQ generation. "

; -------------------- TLM_IRQ_THR_1 member of tlmcom --------------------

  group 0x0008++0x0003
    line.long 0x000 "TLM_IRQ_THR_1, Telemetry interrupt (IRQ) 1 threshold.  Compared against signal selected by tlm_irq_thr_src_sel_1."
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " tlm_irq_gereric_thr_1     ,Telemetry interrupt (IRQ) 1 threshold.  Compared against signal selected by tlm_irq_thr_src_sel_1."
    textline "                   "
    hexmask.long.byte 0x0 16.--20. 0x1 0x0 " tlm_irq_thr_src_sel_1     ,Telemetry interrupt (IRQ) 1 source select.  Selects signal to compare agains tlm_irq_gereric_thr_1 for IRQ generation. "

; -------------------- TLM_IRQ_THR_2 member of tlmcom --------------------

  group 0x000C++0x0003
    line.long 0x000 "TLM_IRQ_THR_2, Telemetry interrupt (IRQ) 2 threshold.  Compared against signal selected by tlm_irq_thr_src_sel_2."
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " tlm_irq_gereric_thr_2     ,Telemetry interrupt (IRQ) 2 threshold.  Compared against signal selected by tlm_irq_thr_src_sel_2."
    textline "                   "
    hexmask.long.byte 0x0 16.--20. 0x1 0x0 " tlm_irq_thr_src_sel_2     ,Telemetry interrupt (IRQ) 2 source select.  Selects signal to compare agains tlm_irq_gereric_thr_2 for IRQ generation. "

; -------------------- TLM_IRQ_THR_3 member of tlmcom --------------------

  group 0x0010++0x0003
    line.long 0x000 "TLM_IRQ_THR_3, Telemetry interrupt (IRQ) 3 threshold.  Compared against signal selected by tlm_irq_thr_src_sel_3."
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " tlm_irq_gereric_thr_3     ,Telemetry interrupt (IRQ) 3 threshold.  Compared against signal selected by tlm_irq_thr_src_sel_3."
    textline "                   "
    hexmask.long.byte 0x0 16.--20. 0x1 0x0 " tlm_irq_thr_src_sel_3     ,Telemetry interrupt (IRQ) 3 source select.  Selects signal to compare agains tlm_irq_gereric_thr_3 for IRQ generation. "

; -------------------- TLM_IRQ_THR_4 member of tlmcom --------------------

  group 0x0014++0x0003
    line.long 0x000 "TLM_IRQ_THR_4, Telemetry interrupt (IRQ) 4 threshold.  Compared against signal selected by tlm_irq_thr_src_sel_4."
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " tlm_irq_gereric_thr_4     ,Telemetry interrupt (IRQ) 4 threshold.  Compared against signal selected by tlm_irq_thr_src_sel_4."
    textline "                   "
    hexmask.long.byte 0x0 16.--20. 0x1 0x0 " tlm_irq_thr_src_sel_4     ,Telemetry interrupt (IRQ) 4 source select.  Selects signal to compare agains tlm_irq_gereric_thr_4 for IRQ generation. "

; -------------------- TLM_IRQ_THR_5 member of tlmcom --------------------

  group 0x0018++0x0003
    line.long 0x000 "TLM_IRQ_THR_5, Telemetry interrupt (IRQ) 5 threshold.  Compared against signal selected by tlm_irq_thr_src_sel_5."
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " tlm_irq_gereric_thr_5     ,Telemetry interrupt (IRQ) 5 threshold.  Compared against signal selected by tlm_irq_thr_src_sel_5."
    textline "                   "
    hexmask.long.byte 0x0 16.--20. 0x1 0x0 " tlm_irq_thr_src_sel_5     ,Telemetry interrupt (IRQ) 5 source select.  Selects signal to compare agains tlm_irq_gereric_thr_5 for IRQ generation. "

; -------------------- TLM_IRQ_THR_6 member of tlmcom --------------------

  group 0x001C++0x0003
    line.long 0x000 "TLM_IRQ_THR_6, Telemetry interrupt (IRQ) 6 threshold.  Compared against signal selected by tlm_irq_thr_src_sel_6."
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " tlm_irq_gereric_thr_6     ,Telemetry interrupt (IRQ) 6 threshold.  Compared against signal selected by tlm_irq_thr_src_sel_6."
    textline "                   "
    hexmask.long.byte 0x0 16.--20. 0x1 0x0 " tlm_irq_thr_src_sel_6     ,Telemetry interrupt (IRQ) 6 source select.  Selects signal to compare agains tlm_irq_gereric_thr_6 for IRQ generation. "

; -------------------- TLM_IRQ_THR_7 member of tlmcom --------------------

  group 0x0020++0x0003
    line.long 0x000 "TLM_IRQ_THR_7, Telemetry interrupt (IRQ) 7 threshold.  Compared against signal selected by tlm_irq_thr_src_sel_7."
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " tlm_irq_gereric_thr_7     ,Telemetry interrupt (IRQ) 7 threshold.  Compared against signal selected by tlm_irq_thr_src_sel_7."
    textline "                   "
    hexmask.long.byte 0x0 16.--20. 0x1 0x0 " tlm_irq_thr_src_sel_7     ,Telemetry interrupt (IRQ) 7 source select.  Selects signal to compare agains tlm_irq_gereric_thr_7 for IRQ generation. "

; -------------------- TLM_IRQ_THR_8 member of tlmcom --------------------

  group 0x0024++0x0003
    line.long 0x000 "TLM_IRQ_THR_8, Telemetry interrupt (IRQ) 8 threshold.  Compared against signal selected by tlm_irq_thr_src_sel_8."
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " tlm_irq_gereric_thr_8     ,Telemetry interrupt (IRQ) 8 threshold.  Compared against signal selected by tlm_irq_thr_src_sel_8."
    textline "                   "
    hexmask.long.byte 0x0 16.--20. 0x1 0x0 " tlm_irq_thr_src_sel_8     ,Telemetry interrupt (IRQ) 8 source select.  Selects signal to compare agains tlm_irq_gereric_thr_8 for IRQ generation. "

; -------------------- TLM_IRQ_THR_9 member of tlmcom --------------------

  group 0x0028++0x0003
    line.long 0x000 "TLM_IRQ_THR_9, Telemetry interrupt (IRQ) 9 threshold.  Compared against signal selected by tlm_irq_thr_src_sel_9."
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " tlm_irq_gereric_thr_9     ,Telemetry interrupt (IRQ) 9 threshold.  Compared against signal selected by tlm_irq_thr_src_sel_9."
    textline "                   "
    hexmask.long.byte 0x0 16.--20. 0x1 0x0 " tlm_irq_thr_src_sel_9     ,Telemetry interrupt (IRQ) 9 source select.  Selects signal to compare agains tlm_irq_gereric_thr_9 for IRQ generation. "

; ------------------- TLM_IRQ_THR_10 member of tlmcom -------------------

  group 0x002C++0x0003
    line.long 0x000 "TLM_IRQ_THR_10, Telemetry interrupt (IRQ) 10 threshold.  Compared against signal selected by tlm_irq_thr_src_sel_10."
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " tlm_irq_gereric_thr_10    ,Telemetry interrupt (IRQ) 10 threshold.  Compared against signal selected by tlm_irq_thr_src_sel_10."
    textline "                   "
    hexmask.long.byte 0x0 16.--20. 0x1 0x0 " tlm_irq_thr_src_sel_10    ,Telemetry interrupt (IRQ) 10 source select.  Selects signal to compare agains tlm_irq_gereric_thr_10 for IRQ generation. "

; ------------------- TLM_IRQ_THR_11 member of tlmcom -------------------

  group 0x0030++0x0003
    line.long 0x000 "TLM_IRQ_THR_11, Telemetry interrupt (IRQ) 11 threshold.  Compared against signal selected by tlm_irq_thr_src_sel_11."
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " tlm_irq_gereric_thr_11    ,Telemetry interrupt (IRQ) 11 threshold.  Compared against signal selected by tlm_irq_thr_src_sel_11."
    textline "                   "
    hexmask.long.byte 0x0 16.--20. 0x1 0x0 " tlm_irq_thr_src_sel_11    ,Telemetry interrupt (IRQ) 11 source select.  Selects signal to compare agains tlm_irq_gereric_thr_11 for IRQ generation. "

; ------------------- TLM_IRQ_THR_12 member of tlmcom -------------------

  group 0x0034++0x0003
    line.long 0x000 "TLM_IRQ_THR_12, Telemetry interrupt (IRQ) 12 threshold.  Compared against signal selected by tlm_irq_thr_src_sel_12."
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " tlm_irq_gereric_thr_12    ,Telemetry interrupt (IRQ) 12 threshold.  Compared against signal selected by tlm_irq_thr_src_sel_12."
    textline "                   "
    hexmask.long.byte 0x0 16.--20. 0x1 0x0 " tlm_irq_thr_src_sel_12    ,Telemetry interrupt (IRQ) 12 source select.  Selects signal to compare agains tlm_irq_gereric_thr_12 for IRQ generation. "

; ------------------- TLM_IRQ_THR_13 member of tlmcom -------------------

  group 0x0038++0x0003
    line.long 0x000 "TLM_IRQ_THR_13, Telemetry interrupt (IRQ) 13 threshold.  Compared against signal selected by tlm_irq_thr_src_sel_13."
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " tlm_irq_gereric_thr_13    ,Telemetry interrupt (IRQ) 13 threshold.  Compared against signal selected by tlm_irq_thr_src_sel_13."
    textline "                   "
    hexmask.long.byte 0x0 16.--20. 0x1 0x0 " tlm_irq_thr_src_sel_13    ,Telemetry interrupt (IRQ) 13 source select.  Selects signal to compare agains tlm_irq_gereric_thr_13 for IRQ generation. "

; ------------------- TLM_IRQ_THR_14 member of tlmcom -------------------

  group 0x003C++0x0003
    line.long 0x000 "TLM_IRQ_THR_14, Telemetry interrupt (IRQ) 14 threshold.  Compared against signal selected by tlm_irq_thr_src_sel_14."
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " tlm_irq_gereric_thr_14    ,Telemetry interrupt (IRQ) 14 threshold.  Compared against signal selected by tlm_irq_thr_src_sel_14."
    textline "                   "
    hexmask.long.byte 0x0 16.--20. 0x1 0x0 " tlm_irq_thr_src_sel_14    ,Telemetry interrupt (IRQ) 14 source select.  Selects signal to compare agains tlm_irq_gereric_thr_14 for IRQ generation. "

; ------------------- TLM_IRQ_THR_15 member of tlmcom -------------------

  group 0x0040++0x0003
    line.long 0x000 "TLM_IRQ_THR_15, Telemetry interrupt (IRQ) 15 threshold.  Compared against signal selected by tlm_irq_thr_src_sel_15."
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " tlm_irq_gereric_thr_15    ,Telemetry interrupt (IRQ) 15 threshold.  Compared against signal selected by tlm_irq_thr_src_sel_15."
    textline "                   "
    hexmask.long.byte 0x0 16.--20. 0x1 0x0 " tlm_irq_thr_src_sel_15    ,Telemetry interrupt (IRQ) 15 source select.  Selects signal to compare agains tlm_irq_gereric_thr_15 for IRQ generation. "

; -------------------- TLM_ATSEN_LPF member of tlmcom --------------------

  rgroup 0x0044++0x0003
    line.long 0x000 "TLM_ATSEN_LPF, Low pass filtered ATSEN telemetry output.  Note that the formate of this register is ADC codes.  The ADC Code to Temperature conversion is implemented in FW."
    textline "                   "
    hexmask.long.word 0x0 0.--9. 0x1 0x0 " tlm_atsen_lpf             ,Low pass filtered ATSEN telemetry output.  Note that the formate of this register is ADC codes.  The ADC Code to Temperature conversion is implemented in FW."

; -------------------- TLM_ATSEN_FS member of tlmcom --------------------

  rgroup 0x0048++0x0003
    line.long 0x000 "TLM_ATSEN_FS, Unfiltered ATSEN telemetry output.  Note that the formate of this register is ADC codes.  The ADC Code to Temperature conversion is implemented in FW."
    textline "                   "
    hexmask.long.word 0x0 0.--11. 0x1 0x0 " tlm_atsen_fs              ,Unfiltered ATSEN telemetry output.  Note that the formate of this register is ADC codes.  The ADC Code to Temperature conversion is implemented in FW."

; -------------------- TLM_BTSEN_LPF member of tlmcom --------------------

  rgroup 0x004C++0x0003
    line.long 0x000 "TLM_BTSEN_LPF, Low pass filtered BTSEN telemetry output.  Note that the formate of this register is ADC codes.  The ADC Code to Temperature conversion is implemented in FW."
    textline "                   "
    hexmask.long.word 0x0 0.--9. 0x1 0x0 " tlm_btsen_lpf             ,Low pass filtered BTSEN telemetry output.  Note that the formate of this register is ADC codes.  The ADC Code to Temperature conversion is implemented in FW."

; -------------------- TLM_BTSEN_FS member of tlmcom --------------------

  rgroup 0x0050++0x0003
    line.long 0x000 "TLM_BTSEN_FS, Unfiltered BTSEN telemetry output.  Note that the formate of this register is ADC codes.  The ADC Code to Temperature conversion is implemented in FW."
    textline "                   "
    hexmask.long.word 0x0 0.--11. 0x1 0x0 " tlm_btsen_fs              ,Unfiltered BTSEN telemetry output.  Note that the formate of this register is ADC codes.  The ADC Code to Temperature conversion is implemented in FW."

; -------------------- TLM_ITSEN_LPF member of tlmcom --------------------

  rgroup 0x0054++0x0003
    line.long 0x000 "TLM_ITSEN_LPF, Low pass filtered ITSEN telemetry output.  Note that the formate of this register is ADC codes.  The ADC Code to Temperature conversion is implemented in FW."
    textline "                   "
    hexmask.long.word 0x0 0.--9. 0x1 0x0 " tlm_itsen_lpf             ,Low pass filtered ITSEN telemetry output.  Note that the formate of this register is ADC codes.  The ADC Code to Temperature conversion is implemented in FW."

; -------------------- TLM_ITSEN_FS member of tlmcom --------------------

  rgroup 0x0058++0x0003
    line.long 0x000 "TLM_ITSEN_FS, Unfiltered ITSEN telemetry output.  Note that the formate of this register is ADC codes.  The ADC Code to Temperature conversion is implemented in FW."
    textline "                   "
    hexmask.long.word 0x0 0.--11. 0x1 0x0 " tlm_itsen_fs              ,Unfiltered ITSEN telemetry output.  Note that the formate of this register is ADC codes.  The ADC Code to Temperature conversion is implemented in FW."

; ------------------ TLM_IRQ_POLARITY member of tlmcom ------------------

  group 0x005C++0x0003
    line.long 0x000 "TLM_IRQ_POLARITY, Telemetry interrupt (IRQ) comparison polarity select where bit [X] corresponds to IRQX. "
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " tlm_irq_polarity          ,Telemetry interrupt (IRQ) comparison polarity select where bit [X] corresponds to IRQX. "

; --------------------- TLM_IRQ_EN member of tlmcom ---------------------

  group 0x0060++0x0003
    line.long 0x000 "TLM_IRQ_EN, Telemetry interrupt (IRQ) enable / clear where bit [X] corresponds to IRQX. "
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " tlm_irq_en                ,Telemetry interrupt (IRQ) enable / clear where bit [X] corresponds to IRQX. "

; -------------------- TLM_IRQ_STAT member of tlmcom --------------------

  rgroup 0x0064++0x0003
    line.long 0x000 "TLM_IRQ_STAT, Telemetry interrupt (IRQ) status where bit [X] corresponds to IRQX. "
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " tlm_irq_stat              ,Telemetry interrupt (IRQ) status where bit [X] corresponds to IRQX. "

; -------------------- TLM_IMON_LPF member of tlmcom --------------------

  rgroup 0x0068++0x0003
    line.long 0x000 "TLM_IMON_LPF, Low pass filtered IMON telemetry output when used as a general purpose ADC."
    textline "                   "
    hexmask.long.word 0x0 0.--13. 0x1 0x0 " tlm_imon_adc_lpf          ,Low pass filtered IMON telemetry output when used as a general purpose ADC."

; ------------------- TLM_PRISEN_LPF member of tlmcom -------------------

  rgroup 0x006C++0x0003
    line.long 0x000 "TLM_PRISEN_LPF, Low pass filtered PRISEN telemetry output when used as a general purpose ADC."
    textline "                   "
    hexmask.long.word 0x0 0.--13. 0x1 0x0 " tlm_prisen_adc_lpf        ,Low pass filtered PRISEN telemetry output when used as a general purpose ADC."

; ------------------ TLM_XADDR_PINSET member of tlmcom ------------------

  rgroup 0x0070++0x0003
    line.long 0x000 "TLM_XADDR_PINSET, XADDR1 pinset measurement decoded value."
    textline "                   "
    hexmask.long.byte 0x0 0.--3. 0x1 0x0 " tlm_xaddr1_pinset         ,XADDR1 pinset measurement decoded value."
    textline "                   "
    hexmask.long.byte 0x0 4.--7. 0x1 0x0 " tlm_xaddr2_pinset         ,XADDR2 pinset measurement decoded value."

; ------------------- TLM_XADDR1_LPF member of tlmcom -------------------

  rgroup 0x0074++0x0003
    line.long 0x000 "TLM_XADDR1_LPF, Low pass filtered XADDR1 telemetry output when used as a general purpose ADC."
    textline "                   "
    hexmask.long.word 0x0 0.--13. 0x1 0x0 " tlm_xaddr1_adc_lpf        ,Low pass filtered XADDR1 telemetry output when used as a general purpose ADC."

; ------------------- TLM_XADDR2_LPF member of tlmcom -------------------

  rgroup 0x0078++0x0003
    line.long 0x000 "TLM_XADDR2_LPF, Low pass filtered XADDR2 telemetry output when used as a general purpose ADC."
    textline "                   "
    hexmask.long.word 0x0 0.--13. 0x1 0x0 " tlm_xaddr2_adc_lpf        ,Low pass filtered XADDR2 telemetry output when used as a general purpose ADC."

tree.end

; -------------------------------------------------------------------
; End Block - tlmcom
; -------------------------------------------------------------------
tree.end
; @file:      trim.per
; Chip name:  SHASTA
; Module:     trim
; 
; Generated by the pmm metagen library.
;
; ===================================================================
; Copyright (C) 2018 Infineon Technologies AG
; All rights reserved.
; ===================================================================
;
; ===================================================================
; This document contains proprietary information. Passing on and
; copying of this document, and communication of its contents is not
; permitted without prior written authorisation.
; ===================================================================

; This file is automatically generated. Do not edit!


config 32. 8.
width 20.

tree "Block - trim"
; -------------------------------------------------------------------
; Begin Block - trim
; -------------------------------------------------------------------
base D:0x70000000

tree "trim"
; ------------------------ BG_TRIM member of trim ------------------------

  group 0x0000++0x0003
    line.long 0x000 "BG_TRIM, Bandgap notch filter enable signal.  Should be enabled during normal operation.  Disable only for test. "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " bg_notch_en               ,Bandgap notch filter enable signal.  Should be enabled during normal operation.  Disable only for test. "
    textline "                   "
    hexmask.long.byte 0x0 1.--7. 0x1 0x0 " bg_trim                   ,Voltage sense reference bandgap trim code.  The nominal setting is 64.  The adjustment is non-linear and given by the equation, "
    textline "                   "
    hexmask.long.byte 0x0 8.--13. 0x1 0x0 " bg_vptat_trim             ,Internal temperature sensor voltage trim code.  With the default trim value of 32 the VPTAT voltage is nominally 647.7 mV at 25C with a slope of 2.7mV/C."
    textline "                   "
    hexmask.long.byte 0x0 14.--18. 0x1 0x0 " sp_reg_lo_trim            ,Oscillator 1.2V linear regulator trim code."
    textline "                   "
    hexmask.long.byte 0x0 19.--23. 0x1 0x0 " sp_reg_vdd_lr_trim        ,Digital 1.2V linear regulator trim code."
    textline "                   "
    hexmask.long.byte 0x0 24.--28. 0x1 0x0 " sp_rega_trim              ,Analog 1.2V linear regulator trim code."

; ------------------------ LO_TRIM member of trim ------------------------

  group 0x0004++0x0003
    line.long 0x000 "LO_TRIM, Oscillator coarse trim code, 200MHz mode.  Nominal setting is 64.  Nominal LO frequency given by equation, "
    textline "                   "
    hexmask.long.byte 0x0 0.--6. 0x1 0x0 " lo_clk_trim_coarse        ,Oscillator coarse trim code, 200MHz mode.  Nominal setting is 64.  Nominal LO frequency given by equation, "
    textline "                   "
    hexmask.long.byte 0x0 7.--13. 0x1 0x0 " lo_clk_trim_coarse_20mhz  ,Oscillator coarse trim code, 20MHz mode."
    textline "                   "
    hexmask.long.byte 0x0 14.--18. 0x1 0x0 " lo_clk_trim_fine          ,Oscillator fine trim code.  Nominal setting is 16.  See lo_clk_coarse_trim description for equation."
    textline "                   "
    hexmask.long.byte 0x0 19.--22. 0x1 0x0 " lo_ptat_trim              ,Oscillator PTAT trim code used to set 0TC for LO frequency.  Nominal setting is 8."

; --------------------- VSP_GAIN_TRIM member of trim ---------------------

  group 0x0008++0x0003
    line.long 0x000 "VSP_GAIN_TRIM, VS0 (VSEN) ADC gain trim."
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " vsp0_adc_gain             ,VS0 (VSEN) ADC gain trim."
    textline "                   "
    hexmask.long.byte 0x0 16.--23. 0x1 0x0 " vsp1_adc_gain             ,VS1 (VRSEN) ADC gain trim."
    textline "                   "
    hexmask.long.byte 0x0 24.--31. 0x1 0x0 " vsp2_adc_gain             ,VS2 (BVSEN_BVRSEN) ADC gain trim."

; --------------------- VSP_OFF_TRIM member of trim ---------------------

  group 0x000C++0x0003
    line.long 0x000 "VSP_OFF_TRIM, VS0 (VSEN) digital offset trim"
    textline "                   "
    hexmask.long.byte 0x0 0.--6. 0x1 0x0 " vsp0_adc_offset           ,VS0 (VSEN) digital offset trim"
    textline "                   "
    hexmask.long.byte 0x0 7.--13. 0x1 0x0 " vsp1_adc_offset           ,VS1 (VRSEN) digital offset trim"
    textline "                   "
    hexmask.long.byte 0x0 14.--20. 0x1 0x0 " vsp2_adc_offset           ,VS2 (BVSEN_BVRSEN) digital offset trim"

; ---------------------- VS_OS_TRIM member of trim ----------------------

  group 0x0010++0x0003
    line.long 0x000 "VS_OS_TRIM, VS0 (VSEN) analog offset trim"
    textline "                   "
    hexmask.long.byte 0x0 0.--6. 0x1 0x0 " vs0_os_trim_bif           ,VS0 (VSEN) analog offset trim"
    textline "                   "
    hexmask.long.byte 0x0 7.--13. 0x1 0x0 " vs1_os_trim_bif           ,VS1 (VRSEN) analog offset trim"
    textline "                   "
    hexmask.long.byte 0x0 14.--20. 0x1 0x0 " vs2_os_trim_bif           ,VS2 (BVSEN_BVRSEN) analog offset trim"

; --------------------- IS1_GAIN_TRIM member of trim ---------------------

  group 0x0014++0x0003
    line.long 0x000 "IS1_GAIN_TRIM, IS1 (ISEN) ADC gain trim when isen1_gain_mode=0."
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " is1_ate_gain0             ,IS1 (ISEN) ADC gain trim when isen1_gain_mode=0."
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " is1_ate_gain1             ,IS1 (ISEN) ADC gain trim when isen1_gain_mode=1."
    textline "                   "
    hexmask.long.byte 0x0 16.--23. 0x1 0x0 " is1_ate_gain2             ,IS1 (ISEN) ADC gain trim when isen1_gain_mode=2."
    textline "                   "
    hexmask.long.byte 0x0 24.--31. 0x1 0x0 " is1_ate_gain3             ,IS1 (ISEN) ADC gain trim when isen1_gain_mode=3."

; --------------------- IS2_GAIN_TRIM member of trim ---------------------

  group 0x0018++0x0003
    line.long 0x000 "IS2_GAIN_TRIM, IS2 (calibration) ADC gain trim when isen1/2_gain_mode=0."
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " is2_ate_gain0             ,IS2 (calibration) ADC gain trim when isen1/2_gain_mode=0."
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " is2_ate_gain1             ,IS2 (calibration) ADC gain trim when isen1/2_gain_mode=1."
    textline "                   "
    hexmask.long.byte 0x0 16.--23. 0x1 0x0 " is2_ate_gain2             ,IS2 (calibration) ADC gain trim when isen1/2_gain_mode=2."
    textline "                   "
    hexmask.long.byte 0x0 24.--31. 0x1 0x0 " is2_ate_gain3             ,IS2 (calibration) ADC gain trim when isen1/2_gain_mode=3."

; --------------------- IS3_GAIN_TRIM member of trim ---------------------

  group 0x001C++0x0003
    line.long 0x000 "IS3_GAIN_TRIM, IS3 (BISEN) ADC gain trim when isen2_gain_mode=0."
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " is3_ate_gain0             ,IS3 (BISEN) ADC gain trim when isen2_gain_mode=0."
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " is3_ate_gain1             ,IS3 (BISEN) ADC gain trim when isen2_gain_mode=1."
    textline "                   "
    hexmask.long.byte 0x0 16.--23. 0x1 0x0 " is3_ate_gain2             ,IS3 (BISEN) ADC gain trim when isen2_gain_mode=2."
    textline "                   "
    hexmask.long.byte 0x0 24.--31. 0x1 0x0 " is3_ate_gain3             ,IS3 (BISEN) ADC gain trim when isen2_gain_mode=3."

; ----------------------- TS_TRIM1 member of trim -----------------------

  group 0x0020++0x0003
    line.long 0x000 "TS_TRIM1, Telemetry ADC, PRISEN input gain trim."
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " prisen_ate_gain           ,Telemetry ADC, PRISEN input gain trim."
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " prisen_ate_offset         ,Telemetry ADC, PRISEN input offset trim."
    textline "                   "
    hexmask.long.byte 0x0 16.--23. 0x1 0x0 " imon_ate_gain             ,Telemetry ADC, IMON input gain trim."
    textline "                   "
    hexmask.long.byte 0x0 24.--31. 0x1 0x0 " imon_ate_offset           ,Telemetry ADC, IMON input offset trim."

; ----------------------- TS_TRIM2 member of trim -----------------------

  group 0x0024++0x0003
    line.long 0x000 "TS_TRIM2, Telemetry ADC, ATSEN input gain trim."
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " atsen_ate_gain            ,Telemetry ADC, ATSEN input gain trim."
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " atsen_ate_offset          ,Telemetry ADC, ATSEN input offset trim."
    textline "                   "
    hexmask.long.byte 0x0 16.--23. 0x1 0x0 " btsen_ate_gain            ,Telemetry ADC, BTSEN input gain trim."
    textline "                   "
    hexmask.long.byte 0x0 24.--31. 0x1 0x0 " btsen_ate_offset          ,Telemetry ADC, BTSEN input offset trim."

; ----------------------- TS_TRIM3 member of trim -----------------------

  group 0x0028++0x0003
    line.long 0x000 "TS_TRIM3, Telemetry ADC, ITSEN input gain trim."
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " itsen_ate_gain            ,Telemetry ADC, ITSEN input gain trim."
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " itsen_ate_offset          ,Telemetry ADC, ITSEN input offset trim."
    textline "                   "
    hexmask.long.byte 0x0 16.--23. 0x1 0x0 " xv_ate_gain               ,Telemetry ADC, XADDR input gain trim."
    textline "                   "
    hexmask.long.byte 0x0 24.--31. 0x1 0x0 " xv_ate_offset             ,Telemetry ADC, XADDR input offset trim."

; ----------------------- TS_TRIM4 member of trim -----------------------

  group 0x002C++0x0003
    line.long 0x000 "TS_TRIM4, Trim code for the 10uA Telemetry Sense IDAC current reference.  Nominal current is 10uA for trim code = 31.  In the nominal corner the range is 8.03 to 12.46uA over codes 0 to 63 but the steps are not linear.  LSB size shown is an average over the range in the nominal corner."
    textline "                   "
    hexmask.long.byte 0x0 0.--5. 0x1 0x0 " ts_tsidac_cur_trim        ,Trim code for the 10uA Telemetry Sense IDAC current reference.  Nominal current is 10uA for trim code = 31.  In the nominal corner the range is 8.03 to 12.46uA over codes 0 to 63 but the steps are not linear.  LSB size shown is an average over the range in the nominal corner."

; ----------------------- IC_SERIAL member of trim -----------------------

  group 0x0030++0x0003
    line.long 0x000 "IC_SERIAL, IC serial number within test lot, programmed at ATE"
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " ic_serial                 ,IC serial number within test lot, programmed at ATE"
    textline "                   "
    hexmask.long.word 0x0 16.--31. 0x1 0x0 " timestamp                 ,ATE test timestamp"

; ------------------------ CFG_NUM member of trim ------------------------

  group 0x0034++0x0003
    line.long 0x000 "CFG_NUM, ATE programmed configuration number"
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " config_num                ,ATE programmed configuration number"
    textline "                   "
    hexmask.long.word 0x0 16.--31. 0x1 0x0 " sw_rev                    ,ATE software revision"

; --------------------- IS1_OFF_TRIM1 member of trim ---------------------

  group 0x0038++0x0003
    line.long 0x000 "IS1_OFF_TRIM1, IS1 (ISEN) ADC offset trim when isen1_gain_mode=0.  Used only when auto calibration is disabled."
    textline "                   "
    hexmask.long.word 0x0 0.--12. 0x1 0x0 " is1_ate_offset0           ,IS1 (ISEN) ADC offset trim when isen1_gain_mode=0.  Used only when auto calibration is disabled."
    textline "                   "
    hexmask.long.word 0x0 13.--25. 0x1 0x0 " is1_ate_offset1           ,IS1 (ISEN) ADC offset trim when isen1_gain_mode=1.  Used only when auto calibration is disabled."

; --------------------- IS1_OFF_TRIM2 member of trim ---------------------

  group 0x003C++0x0003
    line.long 0x000 "IS1_OFF_TRIM2, IS1 (ISEN) ADC offset trim when isen1_gain_mode=2.  Used only when auto calibration is disabled."
    textline "                   "
    hexmask.long.word 0x0 0.--12. 0x1 0x0 " is1_ate_offset2           ,IS1 (ISEN) ADC offset trim when isen1_gain_mode=2.  Used only when auto calibration is disabled."
    textline "                   "
    hexmask.long.word 0x0 13.--25. 0x1 0x0 " is1_ate_offset3           ,IS1 (ISEN) ADC offset trim when isen1_gain_mode=3.  Used only when auto calibration is disabled."
    textline "                   "
    hexmask.long.byte 0x0 26.--26. 0x1 0x0 " is1_dac_trim_en           ,IS1 (ISEN) ADC coarse offset trim enable "
    textline "                   "
    hexmask.long.byte 0x0 27.--28. 0x1 0x0 " is1_dac_trim              ,IS1 (ISEN) coarse offset trim value "

; --------------------- IS2_OFF_TRIM1 member of trim ---------------------

  group 0x0040++0x0003
    line.long 0x000 "IS2_OFF_TRIM1, IS2 (calibration) ADC offset trim when isen2_gain_mode=0.  Used only when auto calibration is disabled."
    textline "                   "
    hexmask.long.word 0x0 0.--12. 0x1 0x0 " is2_ate_offset0           ,IS2 (calibration) ADC offset trim when isen2_gain_mode=0.  Used only when auto calibration is disabled."
    textline "                   "
    hexmask.long.word 0x0 13.--25. 0x1 0x0 " is2_ate_offset1           ,IS2 (calibration) ADC offset trim when isen2_gain_mode=1.  Used only when auto calibration is disabled."

; --------------------- IS2_OFF_TRIM2 member of trim ---------------------

  group 0x0044++0x0003
    line.long 0x000 "IS2_OFF_TRIM2, IS2 (calibration) ADC offset trim when isen2_gain_mode=2.  Used only when auto calibration is disabled."
    textline "                   "
    hexmask.long.word 0x0 0.--12. 0x1 0x0 " is2_ate_offset2           ,IS2 (calibration) ADC offset trim when isen2_gain_mode=2.  Used only when auto calibration is disabled."
    textline "                   "
    hexmask.long.word 0x0 13.--25. 0x1 0x0 " is2_ate_offset3           ,IS2 (calibration) ADC offset trim when isen2_gain_mode=3.  Used only when auto calibration is disabled."
    textline "                   "
    hexmask.long.byte 0x0 26.--26. 0x1 0x0 " is2_dac_trim_en           ,IS2 (calibration) ADC coarse offset trim enable "
    textline "                   "
    hexmask.long.byte 0x0 27.--28. 0x1 0x0 " is2_dac_trim              ,IS2 (calibration) coarse offset trim value "

; --------------------- IS3_OFF_TRIM1 member of trim ---------------------

  group 0x0048++0x0003
    line.long 0x000 "IS3_OFF_TRIM1, IS3 (BISEN) ADC offset trim when isen3_gain_mode=0.  Used only when auto calibration is disabled."
    textline "                   "
    hexmask.long.word 0x0 0.--12. 0x1 0x0 " is3_ate_offset0           ,IS3 (BISEN) ADC offset trim when isen3_gain_mode=0.  Used only when auto calibration is disabled."
    textline "                   "
    hexmask.long.word 0x0 13.--25. 0x1 0x0 " is3_ate_offset1           ,IS3 (BISEN) ADC offset trim when isen3_gain_mode=1.  Used only when auto calibration is disabled."

; --------------------- IS3_OFF_TRIM2 member of trim ---------------------

  group 0x004C++0x0003
    line.long 0x000 "IS3_OFF_TRIM2, IS3 (BISEN) ADC offset trim when isen3_gain_mode=2.  Used only when auto calibration is disabled."
    textline "                   "
    hexmask.long.word 0x0 0.--12. 0x1 0x0 " is3_ate_offset2           ,IS3 (BISEN) ADC offset trim when isen3_gain_mode=2.  Used only when auto calibration is disabled."
    textline "                   "
    hexmask.long.word 0x0 13.--25. 0x1 0x0 " is3_ate_offset3           ,IS3 (BISEN) ADC offset trim when isen3_gain_mode=3.  Used only when auto calibration is disabled."
    textline "                   "
    hexmask.long.byte 0x0 26.--26. 0x1 0x0 " is3_dac_trim_en           ,IS3 (BISEN) ADC coarse offset trim enable "
    textline "                   "
    hexmask.long.byte 0x0 27.--28. 0x1 0x0 " is3_dac_trim              ,IS3 (BISEN) coarse offset trim value "

; ---------------------- SPARE_TRIM member of trim ----------------------

  group 0x0050++0x0003
    line.long 0x000 "SPARE_TRIM, Spare trim register location"
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " spare_trim                ,Spare trim register location"

; ------------------------ PROD_ID member of trim ------------------------

  group 0x0054++0x0003
    line.long 0x000 "PROD_ID, This register indicates the device part number and revision if applicable. Bits [15:8] indicate the device part number (different packages have different part numbers). Bits [7:0] indicate the device revision (e.g., A, B, C, etc.). "
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " product_id                ,This register indicates the device part number and revision if applicable. Bits [15:8] indicate the device part number (different packages have different part numbers). Bits [7:0] indicate the device revision (e.g., A, B, C, etc.). "
    textline "                   "
    hexmask.long.word 0x0 16.--31. 0x1 0x0 " xy_coordinate             ,Wafer coordinate"

; ---------------------- IC_VERSION member of trim ----------------------

  rgroup 0x0058++0x0003
    line.long 0x000 "IC_VERSION, Read only, metal programmed indicator of silicon device ID and revision. Bits [15:4] indicate the product type with 0x010 assigned to Shasta. Bits [3:0] indicate the silicon revision (e.g., A11, B12, etc.). The first silicon revision, A11, will be assigned 0x0. The next silicon revision, whether it be A12, A21 or B11, will be assigned 0x1. Each addition silicon revision will increment this field by 1. If more than 16 revisions are required then a new assignment will be made in bits [15:4].  Current assignments: "
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " ic_version                ,Read only, metal programmed indicator of silicon device ID and revision. Bits [15:4] indicate the product type with 0x010 assigned to Shasta. Bits [3:0] indicate the silicon revision (e.g., A11, B12, etc.). The first silicon revision, A11, will be assigned 0x0. The next silicon revision, whether it be A12, A21 or B11, will be assigned 0x1. Each addition silicon revision will increment this field by 1. If more than 16 revisions are required then a new assignment will be made in bits [15:4].  Current assignments: "

tree.end

; -------------------------------------------------------------------
; End Block - trim
; -------------------------------------------------------------------
tree.end
; @file:      tsen.per
; Chip name:  SHASTA
; Module:     tsen
; 
; Generated by the pmm metagen library.
;
; ===================================================================
; Copyright (C) 2018 Infineon Technologies AG
; All rights reserved.
; ===================================================================
;
; ===================================================================
; This document contains proprietary information. Passing on and
; copying of this document, and communication of its contents is not
; permitted without prior written authorisation.
; ===================================================================

; This file is automatically generated. Do not edit!


config 32. 8.
width 20.

tree "Block - tsen"
; -------------------------------------------------------------------
; Begin Block - tsen
; -------------------------------------------------------------------
base D:0x70004C00

tree "tsen"
; ------------------------ TSEN_EN member of tsen ------------------------

  group 0x0000++0x0003
    line.long 0x000 "TSEN_EN, Telemetry Sense (TS) ADC PRISEN measurement enable.  When enabled, the TS ADC will measure the PRISEN input when selected by ts_muxmode and tx_muxctrl2.  When disabled, no PRISEN measurement will occur, even if selected by ts_muxmode and ts_muxctrl2. "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " prisen_meas_en            ,Telemetry Sense (TS) ADC PRISEN measurement enable.  When enabled, the TS ADC will measure the PRISEN input when selected by ts_muxmode and tx_muxctrl2.  When disabled, no PRISEN measurement will occur, even if selected by ts_muxmode and ts_muxctrl2. "
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " imon_meas_en              ,Telemetry Sense (TS) ADC IMON measurement enable.  When enabled, the TS ADC will measure the IMON input when selected by ts_muxmode and tx_muxctrl2.  When disabled, no IMON measurement will occur, even if selected by ts_muxmode and ts_muxctrl2. "
    textline "                   "
    hexmask.long.byte 0x0 2.--2. 0x1 0x0 " atsen_meas_en             ,Telemetry Sense (TS) ADC ATSEN measurement enable.  When enabled, the TS ADC will measure the ATSEN input when selected by ts_muxmode and tx_muxctrl2.  When disabled, no ATSEN measurement will occur, even if selected by ts_muxmode and ts_muxctrl2. "
    textline "                   "
    hexmask.long.byte 0x0 3.--3. 0x1 0x0 " btsen_meas_en             ,Telemetry Sense (TS) ADC BTSEN measurement enable.  When enabled, the TS ADC will measure the BTSEN input when selected by ts_muxmode and tx_muxctrl2.  When disabled, no BTSEN measurement will occur, even if selected by ts_muxmode and ts_muxctrl2. "
    textline "                   "
    hexmask.long.byte 0x0 4.--4. 0x1 0x0 " itsen_meas_en             ,Telemetry Sense (TS) ADC Internal Temperature (ITSEN) measurement enable.  When enabled, the TS ADC will measure  ITSEN when selected by ts_muxmode and tx_muxctrl2.  When disabled, no ITSEN measurement will occur, even if selected by ts_muxmode, ts_muxctrl1 and ts_muxctrl2. "
    textline "                   "
    hexmask.long.byte 0x0 5.--5. 0x1 0x0 " vref_meas_en              ,Telemetry Sense (TS) ADC 0.6V Reference (VREF) measurement enable.  When enabled, the TS ADC will measure VREF when selected by ts_muxmode and tx_muxctrl2.  When disabled, no VREF measurement will occur, even if selected by ts_muxmode and ts_muxctrl2. "
    textline "                   "
    hexmask.long.byte 0x0 6.--6. 0x1 0x0 " ts_tsidac_antc_sel        ,ATSEN output current source enable.  This current source should be enabled when using the ATSEN input to measure an NTC or PTC temperature sense element.  The current source may be disabled to use the ATSEN input as a general purpose ADC input. "
    textline "                   "
    hexmask.long.byte 0x0 7.--7. 0x1 0x0 " ts_tsidac_bntc_sel        ,BTSEN output current source enable.  This current source should be enabled when using the BTSEN input to measure an NTC or PTC temperature sense element.  The current source may be disabled to use the BTSEN input as a general purpose ADC input. "
    textline "                   "
    hexmask.long.byte 0x0 8.--8. 0x1 0x0 " ts_tsidac_imon_sel        ,IMON output current DAC enable.  This current DAC should be enabled when using the IMON pin for current sharing.  The current DAC should be disabled otherwise. "
    textline "                   "
    hexmask.long.byte 0x0 9.--9. 0x1 0x0 " ts_tsidac_res_sel         ,60K resistor current source enable.  This current source should be enabled during test only. "
    textline "                   "
    hexmask.long.byte 0x0 10.--10. 0x1 0x0 " ts_tsidac_xv1_sel         ,XADDR1 output current DAC enable.  This current DAC is enabled by FW during the XADDR1 resistor pinset measurement.  The current DAC should be disabled otherwise. "
    textline "                   "
    hexmask.long.byte 0x0 11.--11. 0x1 0x0 " ts_tsidac_xv2_sel         ,XADDR2 output current DAC enable.  This current DAC is enabled by FW during the XADDR2 resistor pinset measurement.  The current DAC should be disabled otherwise. "
    textline "                   "
    hexmask.long.byte 0x0 12.--12. 0x1 0x0 " xv_decode_sel             ,XValent Address Table Select.  Defines the size of the look up table used to decode the XADDR1 and XADDR2 resistor pinset values. "
    textline "                   "
    hexmask.long.byte 0x0 13.--13. 0x1 0x0 " xv_pinset1_meas           ,XADDR1 Pinset Measure Control "
    textline "                   "
    hexmask.long.byte 0x0 14.--14. 0x1 0x0 " xv_pinset2_meas           ,XADDR2 Pinset Measure Control "
    textline "                   "
    hexmask.long.byte 0x0 15.--16. 0x1 0x0 " ts_muxctrl1               ,Telemetry Sense (TS) ADC MUX1 input source select.  The output of MUX1 is connected to MUX2 input 7. "
    textline "                   "
    hexmask.long.byte 0x0 17.--19. 0x1 0x0 " ts_muxctrl2               ,Telemetry Sense (TS) ADC MUX2 input source select.  The output of MUX2 is connected to the TS ADC input. "
    textline "                   "
    hexmask.long.byte 0x0 20.--22. 0x1 0x0 " ts_muxmode                ,Telemetry Sense (TS) ADC input sequence control.  When bit [2] is 0, the TS ADC input is entirely determined by the settings of ts_muxctrl1 and ts_muxctrl2.  When bit [2] is 1, MUX2 auto-sequences its input using the pattern in the table below.  If the sequence include MUX2 input 7 (MUX1), the source in this timeslot is determined by the setting of ts_muxctrl1. "

; ---------------------- TSEN_PTAT1 member of tsen ----------------------

  group 0x0004++0x0003
    line.long 0x000 "TSEN_PTAT1, Not used"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " ptat_min_code             ,Not used"
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " ptat_temp_trim            ,Internal temperature sense (ITSEN) offset term  Internal temperature computed as: "
    textline "                   "
    hexmask.long.word 0x0 16.--27. 0x1 0x0 " ptat_pwl_slope            ,Internal temperature sense (ITSEN) piecewise linear slope term.  Internal temperature computed as: "

; ---------------------- TSEN_PTAT2 member of tsen ----------------------

  group 0x0008++0x0003
    line.long 0x000 "TSEN_PTAT2, Internal temperature sense (ITSEN) 0C code.  Internal temperature computed as: "
    textline "                   "
    hexmask.long.word 0x0 0.--10. 0x1 0x0 " ptat_0c_code              ,Internal temperature sense (ITSEN) 0C code.  Internal temperature computed as: "
    textline "                   "
    hexmask.long.byte 0x0 11.--18. 0x1 0x0 " temp_min                  ,Defines the lower limit for the internal temperature computation.  Computed results less than this value are clamped to this value."
    textline "                   "
    hexmask.long.byte 0x0 19.--26. 0x1 0x0 " xv_gain_scale             ,XADDR1,2 computation gain scale.  The TS ADC result is scaled by (1.0 + xv_gain_scale) during the XADDR computations."

; ----------------------- TSEN_VIN member of tsen -----------------------

  group 0x000C++0x0003
    line.long 0x000 "TSEN_VIN, Telemetry sense ADC PRISEN input voltage (Vin) piecewise linear slope term.  Vin computed as: "
    textline "                   "
    hexmask.long.word 0x0 0.--11. 0x1 0x0 " vin_pwl_slope             ,Telemetry sense ADC PRISEN input voltage (Vin) piecewise linear slope term.  Vin computed as: "
    textline "                   "
    hexmask.long.word 0x0 12.--21. 0x1 0x0 " vin_trim                  ,Telemetry sense ADC PRISEN input voltage (Vin) offset term.  Vin computed as: "

; --------------------- TSEN_XV_DONE member of tsen ---------------------

  rgroup 0x0010++0x0003
    line.long 0x000 "TSEN_XV_DONE, Telemetry sense ADC XADDR measurement complete status. "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " ts_xv_complete            ,Telemetry sense ADC XADDR measurement complete status. "

; ---------------------- TSEN_PRIADC member of tsen ----------------------

  rgroup 0x0014++0x0003
    line.long 0x000 "TSEN_PRIADC, Gain and offset corrected PRISEN Telemetry Sense (TS) ADC output."
    textline "                   "
    hexmask.long.word 0x0 0.--13. 0x1 0x0 " ts_prisen_adc             ,Gain and offset corrected PRISEN Telemetry Sense (TS) ADC output."

; ---------------------- TSEN_IMNADC member of tsen ----------------------

  rgroup 0x0018++0x0003
    line.long 0x000 "TSEN_IMNADC, Gain and offset corrected IMON Telemetry Sense (TS) ADC output."
    textline "                   "
    hexmask.long.word 0x0 0.--13. 0x1 0x0 " ts_imon_adc               ,Gain and offset corrected IMON Telemetry Sense (TS) ADC output."

; ---------------------- TSEN_ATSADC member of tsen ----------------------

  rgroup 0x001C++0x0003
    line.long 0x000 "TSEN_ATSADC, Gain and offset corrected ATSEN Telemetry Sense (TS) ADC output."
    textline "                   "
    hexmask.long.word 0x0 0.--13. 0x1 0x0 " ts_atsen_adc              ,Gain and offset corrected ATSEN Telemetry Sense (TS) ADC output."

; ---------------------- TSEN_BTSADC member of tsen ----------------------

  rgroup 0x0020++0x0003
    line.long 0x000 "TSEN_BTSADC, Gain and offset corrected BTSEN Telemetry Sense (TS) ADC output."
    textline "                   "
    hexmask.long.word 0x0 0.--13. 0x1 0x0 " ts_btsen_adc              ,Gain and offset corrected BTSEN Telemetry Sense (TS) ADC output."

; ---------------------- TSEN_ITSADC member of tsen ----------------------

  rgroup 0x0024++0x0003
    line.long 0x000 "TSEN_ITSADC, Gain and offset corrected ITSEN (internal temp) Telemetry Sense (TS) ADC output."
    textline "                   "
    hexmask.long.word 0x0 0.--13. 0x1 0x0 " ts_itsen_adc              ,Gain and offset corrected ITSEN (internal temp) Telemetry Sense (TS) ADC output."

; ---------------------- TSEN_VRFADC member of tsen ----------------------

  rgroup 0x0028++0x0003
    line.long 0x000 "TSEN_VRFADC, Gain and offset corrected VREF (0.6V reference)Telemetry Sense (TS) ADC output."
    textline "                   "
    hexmask.long.word 0x0 0.--13. 0x1 0x0 " vref_adc                  ,Gain and offset corrected VREF (0.6V reference)Telemetry Sense (TS) ADC output."

; ---------------------- TSEN_XV1ADC member of tsen ----------------------

  rgroup 0x002C++0x0003
    line.long 0x000 "TSEN_XV1ADC, Gain and offset corrected XADDR1 Telemetry Sense (TS) ADC output."
    textline "                   "
    hexmask.long.word 0x0 0.--13. 0x1 0x0 " xv1_adc                   ,Gain and offset corrected XADDR1 Telemetry Sense (TS) ADC output."

; ---------------------- TSEN_XV2ADC member of tsen ----------------------

  rgroup 0x0030++0x0003
    line.long 0x000 "TSEN_XV2ADC, Gain and offset corrected XADDR2 Telemetry Sense (TS) ADC output."
    textline "                   "
    hexmask.long.word 0x0 0.--13. 0x1 0x0 " xv2_adc                   ,Gain and offset corrected XADDR2 Telemetry Sense (TS) ADC output."

; ---------------------- TSEN_ITEMP member of tsen ----------------------

  rgroup 0x0034++0x0003
    line.long 0x000 "TSEN_ITEMP, Low pass filtered internal temperature (ITSEN) measurement.  Filter BW fixed at approximately 950Hz when the ITSEN measurement is enabled via ts_muxmode and ts_muxctrl1."
    textline "                   "
    hexmask.long.word 0x0 0.--11. 0x1 0x0 " int_temp                  ,Low pass filtered internal temperature (ITSEN) measurement.  Filter BW fixed at approximately 950Hz when the ITSEN measurement is enabled via ts_muxmode and ts_muxctrl1."

tree.end

; -------------------------------------------------------------------
; End Block - tsen
; -------------------------------------------------------------------
tree.end
; @file:      tstctrl.per
; Chip name:  SHASTA
; Module:     tstctrl
; 
; Generated by the pmm metagen library.
;
; ===================================================================
; Copyright (C) 2018 Infineon Technologies AG
; All rights reserved.
; ===================================================================
;
; ===================================================================
; This document contains proprietary information. Passing on and
; copying of this document, and communication of its contents is not
; permitted without prior written authorisation.
; ===================================================================

; This file is automatically generated. Do not edit!


config 32. 8.
width 20.

tree "Block - tstctrl"
; -------------------------------------------------------------------
; Begin Block - tstctrl
; -------------------------------------------------------------------
base D:0x40005000

tree "tstctrl"
; ------------------- ATE_TEST_MODE member of tstctrl -------------------

  rgroup 0x0000++0x0003
    line.long 0x000 "ATE_TEST_MODE, ATE TEST MODE Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " ATE_TM_STATE              ,1: TEST MODE ON"
    textline "                   "
    hexmask.long.byte 0x0 16.--16. 0x1 0x0 " TEST_GATE                 ,1: XADDR1_IN Latched Logic1 "
    textline "                   "
    hexmask.long.byte 0x0 17.--17. 0x1 0x0 " XADDR1_IN                 ,1: XADDR1_IN input buffer at Logic1"

; --------------------- TEST_CONF member of tstctrl ---------------------

  rgroup 0x0004++0x0003
    line.long 0x000 "TEST_CONF, IDCODE register "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " EDT_BYPASS                ,EDT_BYPASS status"
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " SCAN_TYPE_SEL             ,SCAN_TYPE_SEL status"
    textline "                   "
    hexmask.long.byte 0x0 2.--2. 0x1 0x0 " SCAN_MODE                 ,SCAN_MODEstatus"
    textline "                   "
    hexmask.long.byte 0x0 3.--3. 0x1 0x0 " SCAN_ANA_BYPASS           ,SCAN_ANA_BYPASS status"
    textline "                   "
    hexmask.long.byte 0x0 8.--8. 0x1 0x0 " ATE_TM_CLK_EN             ,1: Enables clock configuration"
    textline "                   "
    hexmask.long.byte 0x0 9.--9. 0x1 0x0 " ATE_TM_TRIM_DOWNLOAD      ,1: Enables the trimming configuration download"
    textline "                   "
    hexmask.long.byte 0x0 10.--10. 0x1 0x0 " ATE_TM_FULL_BOOT          ,1: Enables the full boot"
    textline "                   "
    hexmask.long.byte 0x0 16.--16. 0x1 0x0 " CLK_SEL                   ,CLK_SEL status"
    textline "                   "
    hexmask.long.byte 0x0 17.--17. 0x1 0x0 " LO_DIS                    ,LO_DIS status"
    textline "                   "
    hexmask.long.byte 0x0 18.--18. 0x1 0x0 " LO_SLEEP_EN               ,LO_SLEEP_EN status"
    textline "                   "
    hexmask.long.byte 0x0 30.--30. 0x1 0x0 " SP_LDO_DIS                ,SP_LDO_DIS status"
    textline "                   "
    hexmask.long.byte 0x0 31.--31. 0x1 0x0 " SP_REGA_DIS               ,SP_REGA_DIS status"

; ----------------------- MBIST member of tstctrl -----------------------

  rgroup 0x0008++0x0003
    line.long 0x000 "MBIST, IDCODE register "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " RAM1_DONE                 ,RAM1_DONE status"
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " RAM2_DONE                 ,RAM2_DONE status"
    textline "                   "
    hexmask.long.byte 0x0 2.--2. 0x1 0x0 " ROM_DONE                  ,ROM_DONE status"
    textline "                   "
    hexmask.long.byte 0x0 9.--9. 0x1 0x0 " RAM1_START                ,RAM1_START status"
    textline "                   "
    hexmask.long.byte 0x0 10.--10. 0x1 0x0 " RAM2_START                ,RAM2_START status"
    textline "                   "
    hexmask.long.byte 0x0 11.--11. 0x1 0x0 " ROM_START                 ,ROM_START status"
    textline "                   "
    hexmask.long.byte 0x0 13.--13. 0x1 0x0 " ROM_DEBUG                 ,ROM_DEBUG status"
    textline "                   "
    hexmask.long.byte 0x0 14.--14. 0x1 0x0 " RAM_DEBUG                 ,RAM_DEBUG status"
    textline "                   "
    hexmask.long.byte 0x0 15.--15. 0x1 0x0 " MBIST_RSTN                ,MBIST_RSTN status"
    textline "                   "
    hexmask.long.byte 0x0 16.--16. 0x1 0x0 " RAM1_FAIL                 ,RAM1_FAIL status"
    textline "                   "
    hexmask.long.byte 0x0 17.--17. 0x1 0x0 " RAM2_FAIL                 ,RAM2_FAIL status"
    textline "                   "
    hexmask.long.byte 0x0 23.--24. 0x1 0x0 " RAM1_SLOWB                ,RAM1_SLOWB status"
    textline "                   "
    hexmask.long.byte 0x0 25.--26. 0x1 0x0 " RAM2_SLOWB                ,RAM2_SLOWB status"
    textline "                   "
    hexmask.long.byte 0x0 27.--28. 0x1 0x0 " ROM_SLOWB                 ,ROM_SLOWB status"
    textline "                   "
    hexmask.long.byte 0x0 29.--29. 0x1 0x0 " IOMUX_CTRL                ,IOMUX_CTRL status"
    textline "                   "
    hexmask.long.byte 0x0 30.--30. 0x1 0x0 " RAM_SEL                   ,RAM_SEL status"
    textline "                   "
    hexmask.long.byte 0x0 31.--31. 0x1 0x0 " MBIST_MODE                ,MBIST_MODE status"

; ---------------------- ROM_MISR member of tstctrl ----------------------

  rgroup 0x000C++0x0003
    line.long 0x000 "ROM_MISR, ROM MISR Register"

; ---------------------- SYSRESET member of tstctrl ----------------------

  rgroup 0x0010++0x0003
    line.long 0x000 "SYSRESET, SYSRESET Register"

tree.end

; -------------------------------------------------------------------
; End Block - tstctrl
; -------------------------------------------------------------------
tree.end
; @file:      uart.per
; Chip name:  SHASTA
; Module:     uart
; 
; Generated by the pmm metagen library.
;
; ===================================================================
; Copyright (C) 2018 Infineon Technologies AG
; All rights reserved.
; ===================================================================
;
; ===================================================================
; This document contains proprietary information. Passing on and
; copying of this document, and communication of its contents is not
; permitted without prior written authorisation.
; ===================================================================

; This file is automatically generated. Do not edit!


config 32. 8.
width 20.

tree "Block - uart"
; -------------------------------------------------------------------
; Begin Block - uart
; -------------------------------------------------------------------
base D:0x700C0000

tree "uart"
; ------------------------ UARTDR member of uart ------------------------

  group 0x0000++0x0003
    line.long 0x000 "UARTDR, UART Data Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " DATA                      ,Data Character"
    textline "                   "
    hexmask.long.byte 0x0 8.--8. 0x1 0x0 " FE                        ,Framing Error"
    textline "                   "
    hexmask.long.byte 0x0 9.--9. 0x1 0x0 " PE                        ,Parity Error"
    textline "                   "
    hexmask.long.byte 0x0 10.--10. 0x1 0x0 " BE                        ,Break Error"
    textline "                   "
    hexmask.long.byte 0x0 11.--11. 0x1 0x0 " OE                        ,Overrun Error"

; -------------------- UARTRSR_UARTECR member of uart --------------------

  group 0x0004++0x0003
    line.long 0x000 "UARTRSR_UARTECR, Receive Status Register/Error Clear Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " FE                        ,Framing Error"
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " PE                        ,Parity Error"
    textline "                   "
    hexmask.long.byte 0x0 2.--2. 0x1 0x0 " BE                        ,Break Error"
    textline "                   "
    hexmask.long.byte 0x0 3.--3. 0x1 0x0 " OE                        ,Overrun Error"

; ------------------------ UARTFR member of uart ------------------------

  rgroup 0x0018++0x0003
    line.long 0x000 "UARTFR, Flag Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " CTS                       ,Clear to send"
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " DSR                       ,Data set ready"
    textline "                   "
    hexmask.long.byte 0x0 2.--2. 0x1 0x0 " DCD                       ,Data carrier detect"
    textline "                   "
    hexmask.long.byte 0x0 3.--3. 0x1 0x0 " BUSY                      ,UART busy"
    textline "                   "
    hexmask.long.byte 0x0 4.--4. 0x1 0x0 " RXFE                      ,Receive FIFO empty"
    textline "                   "
    hexmask.long.byte 0x0 5.--5. 0x1 0x0 " TXFF                      ,Transmit FIFO full"
    textline "                   "
    hexmask.long.byte 0x0 6.--6. 0x1 0x0 " RXFF                      ,Receive FIFO full"
    textline "                   "
    hexmask.long.byte 0x0 7.--7. 0x1 0x0 " TXFE                      ,Transmit FIFO empty"
    textline "                   "
    hexmask.long.byte 0x0 8.--8. 0x1 0x0 " RI                        ,Ring indicator"

; ----------------------- UARTILPR member of uart -----------------------

  group 0x0020++0x0003
    line.long 0x000 "UARTILPR, IrDA Low-Power Counter Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " ILPDVSR                   ,8-bit low-power divisor value"

; ----------------------- UARTIBRD member of uart -----------------------

  group 0x0024++0x0003
    line.long 0x000 "UARTIBRD, Integer Baud Rate Register"
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " BAUD_DIVINT               ,Integer baud rate divisor"

; ----------------------- UARTFBRD member of uart -----------------------

  group 0x0028++0x0003
    line.long 0x000 "UARTFBRD, Fractional Baud Rate Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--5. 0x1 0x0 " BAUD_DIVFRAC              ,Fractional baud rate divisor"

; ----------------------- UARTLCR_H member of uart -----------------------

  group 0x002C++0x0003
    line.long 0x000 "UARTLCR_H, Line Control Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " BRK                       ,Send break"
    textline "                   "
    bitfld.long 0x0 1. " PEN                       ,Parity enable" "LOW (0),HIGH (1)"
    textline "                   "
    bitfld.long 0x0 2. " EPS                       ,Even parity select" "LOW (0),HIGH (1)"
    textline "                   "
    hexmask.long.byte 0x0 3.--3. 0x1 0x0 " STP2                      ,Two stop bits select"
    textline "                   "
    bitfld.long 0x0 4. " FEN                       ,Enable FIFOs" "LOW (0),HIGH (1)"
    textline "                   "
    bitfld.long 0x0 5.--6. " WLEN                      ,Word length" "S0 (0),S1 (1),S2 (2),S3 (3)"
    textline "                   "
    bitfld.long 0x0 7. " SPS                       ,Stick parity select" "LOW (0),HIGH (1)"

; ------------------------ UARTCR member of uart ------------------------

  group 0x0030++0x0003
    line.long 0x000 "UARTCR, Control Register"
    textline "                   "
    bitfld.long 0x0 0. " UARTEN                    ,UART enable" "LOW (0),HIGH (1)"
    textline "                   "
    bitfld.long 0x0 1. " SIREN                     ,SIR enable" "LOW (0),HIGH (1)"
    textline "                   "
    hexmask.long.byte 0x0 2.--2. 0x1 0x0 " SIRLP                     ,SIR low-power IrDA mode"
    textline "                   "
    hexmask.long.byte 0x0 7.--7. 0x1 0x0 " LBE                       ,Loopback enable"
    textline "                   "
    hexmask.long.byte 0x0 8.--8. 0x1 0x0 " TXE                       ,Transmit enable"
    textline "                   "
    hexmask.long.byte 0x0 9.--9. 0x1 0x0 " RXE                       ,Receive enable"
    textline "                   "
    hexmask.long.byte 0x0 10.--10. 0x1 0x0 " DTR                       ,Data transmit ready"
    textline "                   "
    hexmask.long.byte 0x0 11.--11. 0x1 0x0 " RTS                       ,Request to send"
    textline "                   "
    hexmask.long.byte 0x0 12.--12. 0x1 0x0 " OUT1                      ,Complement of the UART Out1 Modem Status Output"
    textline "                   "
    hexmask.long.byte 0x0 13.--13. 0x1 0x0 " OUT2                      ,Complement of the UART Out2 Modem Status Output"
    textline "                   "
    bitfld.long 0x0 14. " RTSEn                     ,RTS hardware flow control enable" "LOW (0),HIGH (1)"
    textline "                   "
    bitfld.long 0x0 15. " CTSEn                     ,CTS hardware flow control enable" "LOW (0),HIGH (1)"

; ----------------------- UARTIFLS member of uart -----------------------

  group 0x0034++0x0003
    line.long 0x000 "UARTIFLS, Interrupt FIFO Level Select Register"
    textline "                   "
    bitfld.long 0x0 0.--2. " TXIFLSEL                  ,Transmit interrupt FIFO level select" "S6S7 (0),S1 (1),S2 (2),S3 (3),S4 (4),S5 (5),%d..."
    textline "                   "
    bitfld.long 0x0 3.--5. " RXIFLSEL                  ,Receive interrupt FIFO level select" "S6S7 (0),S1 (1),S2 (2),S3 (3),S4 (4),S5 (5),%d..."

; ----------------------- UARTIMSC member of uart -----------------------

  group 0x0038++0x0003
    line.long 0x000 "UARTIMSC, Interrupt Mask Set/Clear Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " RIMIM                     ,nUARTRI modem interrupt mask"
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " CTSMIM                    ,nUARTCTS modem interrupt mask"
    textline "                   "
    hexmask.long.byte 0x0 2.--2. 0x1 0x0 " DCDMIM                    ,nUARTDCD modem interrupt mask"
    textline "                   "
    hexmask.long.byte 0x0 3.--3. 0x1 0x0 " DSRMIM                    ,nUARTDSR modem interrupt mask"
    textline "                   "
    hexmask.long.byte 0x0 4.--4. 0x1 0x0 " RXIM                      ,Receive interrupt mask"
    textline "                   "
    hexmask.long.byte 0x0 5.--5. 0x1 0x0 " TXIM                      ,Transmit interrupt mask"
    textline "                   "
    hexmask.long.byte 0x0 6.--6. 0x1 0x0 " RTIM                      ,Receive timeout interrupt mask"
    textline "                   "
    hexmask.long.byte 0x0 7.--7. 0x1 0x0 " FEIM                      ,Framing error interrupt mask"
    textline "                   "
    hexmask.long.byte 0x0 8.--8. 0x1 0x0 " PEIM                      ,Parity error interrupt mask"
    textline "                   "
    hexmask.long.byte 0x0 9.--9. 0x1 0x0 " BEIM                      ,Break error interrupt mask"
    textline "                   "
    hexmask.long.byte 0x0 10.--10. 0x1 0x0 " OEIM                      ,Overrun error interrupt mask"

; ------------------------ UARTRIS member of uart ------------------------

  rgroup 0x003C++0x0003
    line.long 0x000 "UARTRIS, Raw Interrupt Status Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " RIRMIS                    ,nUARTRI modem interrupt status"
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " CTSRMIS                   ,nUARTCTS modem interrupt status"
    textline "                   "
    hexmask.long.byte 0x0 2.--2. 0x1 0x0 " DCDRMIS                   ,nUARTDCD modem interrupt status"
    textline "                   "
    hexmask.long.byte 0x0 3.--3. 0x1 0x0 " DSRRMIS                   ,nUARTDSR modem interrupt status"
    textline "                   "
    hexmask.long.byte 0x0 4.--4. 0x1 0x0 " RXRIS                     ,Receive interrupt status"
    textline "                   "
    hexmask.long.byte 0x0 5.--5. 0x1 0x0 " TXRIS                     ,Transmit interrupt status"
    textline "                   "
    hexmask.long.byte 0x0 6.--6. 0x1 0x0 " RTRIS                     ,Receive timeout interrupt status"
    textline "                   "
    hexmask.long.byte 0x0 7.--7. 0x1 0x0 " FERIS                     ,Framing error interrupt status"
    textline "                   "
    hexmask.long.byte 0x0 8.--8. 0x1 0x0 " PERIS                     ,Parity error interrupt status"
    textline "                   "
    hexmask.long.byte 0x0 9.--9. 0x1 0x0 " BERIS                     ,Break error interrupt status"
    textline "                   "
    hexmask.long.byte 0x0 10.--10. 0x1 0x0 " OERIS                     ,Overrun error interrupt status"

; ------------------------ UARTMIS member of uart ------------------------

  rgroup 0x0040++0x0003
    line.long 0x000 "UARTMIS, Masked Interrupt Status Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " RIMMIS                    ,nUARTRI modem masked interrupt status"
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " CTSMMIS                   ,nUARTCTS modem masked interrupt status"
    textline "                   "
    hexmask.long.byte 0x0 2.--2. 0x1 0x0 " DCDMMIS                   ,nUARTDCD modem masked interrupt status"
    textline "                   "
    hexmask.long.byte 0x0 3.--3. 0x1 0x0 " DSRMMIS                   ,nUARTDSR modem masked interrupt status"
    textline "                   "
    hexmask.long.byte 0x0 4.--4. 0x1 0x0 " RXMIS                     ,Receive masked interrupt status"
    textline "                   "
    hexmask.long.byte 0x0 5.--5. 0x1 0x0 " TXMIS                     ,Transmit masked interrupt status"
    textline "                   "
    hexmask.long.byte 0x0 6.--6. 0x1 0x0 " RTMIS                     ,Receive timeout masked interrupt status"
    textline "                   "
    hexmask.long.byte 0x0 7.--7. 0x1 0x0 " FEMIS                     ,Framing error masked interrupt status"
    textline "                   "
    hexmask.long.byte 0x0 8.--8. 0x1 0x0 " PEMIS                     ,Parity error masked interrupt status"
    textline "                   "
    hexmask.long.byte 0x0 9.--9. 0x1 0x0 " BEMIS                     ,Break error masked interrupt status"
    textline "                   "
    hexmask.long.byte 0x0 10.--10. 0x1 0x0 " OEMIS                     ,Overrun error masked interrupt status"

; ------------------------ UARTICR member of uart ------------------------

  group 0x0044++0x0003
    line.long 0x000 "UARTICR, Interrupt Clear Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " RIMIC                     ,nUARTRI modem interrupt clear"
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " CTSMIC                    ,nUARTCTS modem interrupt clear"
    textline "                   "
    hexmask.long.byte 0x0 2.--2. 0x1 0x0 " DCDMIC                    ,nUARTDCD modem interrupt clear"
    textline "                   "
    hexmask.long.byte 0x0 3.--3. 0x1 0x0 " DSRMIC                    ,nUARTDSR modem interrupt clear"
    textline "                   "
    hexmask.long.byte 0x0 4.--4. 0x1 0x0 " RXIC                      ,Receive interrupt clear"
    textline "                   "
    hexmask.long.byte 0x0 5.--5. 0x1 0x0 " TXIC                      ,Transmit interrupt clear"
    textline "                   "
    hexmask.long.byte 0x0 6.--6. 0x1 0x0 " RTIC                      ,Receive timeout interrupt clear"
    textline "                   "
    hexmask.long.byte 0x0 7.--7. 0x1 0x0 " FEIC                      ,Framing error interrupt clear"
    textline "                   "
    hexmask.long.byte 0x0 8.--8. 0x1 0x0 " PEIC                      ,Parity error interrupt clear"
    textline "                   "
    hexmask.long.byte 0x0 9.--9. 0x1 0x0 " BEIC                      ,Break error interrupt clear"
    textline "                   "
    hexmask.long.byte 0x0 10.--10. 0x1 0x0 " OEIC                      ,Overrun error interrupt clear"

; ----------------------- UARTDMACR member of uart -----------------------

  group 0x0048++0x0003
    line.long 0x000 "UARTDMACR, DMA Control Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " RXDMAE                    ,Receive DMA enable"
    textline "                   "
    hexmask.long.byte 0x0 1.--1. 0x1 0x0 " TXDMAE                    ,Transmit DMA enable"
    textline "                   "
    hexmask.long.byte 0x0 2.--2. 0x1 0x0 " DMAONERR                  ,DMA on error"

; ------------------------ UARTTCR member of uart ------------------------

  rgroup 0x0080++0x0003
    line.long 0x000 "UARTTCR,  CrossRefz "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " UARTPCellID0              ,UARTPCellID0"
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " UARTPCellID1              ,UARTPCellID1"
    textline "                   "
    hexmask.long.byte 0x0 16.--23. 0x1 0x0 " UARTPCellID2              ,UARTPCellID2"
    textline "                   "
    hexmask.long.byte 0x0 24.--31. 0x1 0x0 " UARTPCellID3              ,UARTPCellID3"

; ----------------------- UARTITIP member of uart -----------------------

  rgroup 0x0084++0x0003
    line.long 0x000 "UARTITIP,  CrossRefz "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " UARTPCellID0              ,UARTPCellID0"
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " UARTPCellID1              ,UARTPCellID1"
    textline "                   "
    hexmask.long.byte 0x0 16.--23. 0x1 0x0 " UARTPCellID2              ,UARTPCellID2"
    textline "                   "
    hexmask.long.byte 0x0 24.--31. 0x1 0x0 " UARTPCellID3              ,UARTPCellID3"

; ----------------------- UARTITOP member of uart -----------------------

  rgroup 0x0088++0x0003
    line.long 0x000 "UARTITOP,  CrossRefz "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " UARTPCellID0              ,UARTPCellID0"
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " UARTPCellID1              ,UARTPCellID1"
    textline "                   "
    hexmask.long.byte 0x0 16.--23. 0x1 0x0 " UARTPCellID2              ,UARTPCellID2"
    textline "                   "
    hexmask.long.byte 0x0 24.--31. 0x1 0x0 " UARTPCellID3              ,UARTPCellID3"

; ------------------------ UARTTDR member of uart ------------------------

  rgroup 0x008C++0x0003
    line.long 0x000 "UARTTDR,  CrossRefz "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " UARTPCellID0              ,UARTPCellID0"
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " UARTPCellID1              ,UARTPCellID1"
    textline "                   "
    hexmask.long.byte 0x0 16.--23. 0x1 0x0 " UARTPCellID2              ,UARTPCellID2"
    textline "                   "
    hexmask.long.byte 0x0 24.--31. 0x1 0x0 " UARTPCellID3              ,UARTPCellID3"

; --------------------- UARTPeriphID member of uart ---------------------

  rgroup 0x0FE0++0x0003
    line.long 0x000 "UARTPeriphID, Peripheral Identification Register"
    textline "                   "
    hexmask.long.word 0x0 0.--11. 0x1 0x0 " PARTNUM                   ,PartNumber"
    textline "                   "
    hexmask.long.byte 0x0 12.--19. 0x1 0x0 " DESID                     ,Designer ID"
    textline "                   "
    hexmask.long.byte 0x0 20.--23. 0x1 0x0 " REV                       ,Revision"
    textline "                   "
    hexmask.long.byte 0x0 24.--31. 0x1 0x0 " CONFIG                    ,Configuration"

; ---------------------- UARTPCellID member of uart ----------------------

  rgroup 0x0FF0++0x0003
    line.long 0x000 "UARTPCellID, PrimeCell Identification Register"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " UARTPCellID0              ,UARTPCellID0"
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " UARTPCellID1              ,UARTPCellID1"
    textline "                   "
    hexmask.long.byte 0x0 16.--23. 0x1 0x0 " UARTPCellID2              ,UARTPCellID2"
    textline "                   "
    hexmask.long.byte 0x0 24.--31. 0x1 0x0 " UARTPCellID3              ,UARTPCellID3"

tree.end

; -------------------------------------------------------------------
; End Block - uart
; -------------------------------------------------------------------
tree.end
; @file:      vcontrol.per
; Chip name:  SHASTA
; Module:     vcontrol
; 
; Generated by the pmm metagen library.
;
; ===================================================================
; Copyright (C) 2018 Infineon Technologies AG
; All rights reserved.
; ===================================================================
;
; ===================================================================
; This document contains proprietary information. Passing on and
; copying of this document, and communication of its contents is not
; permitted without prior written authorisation.
; ===================================================================

; This file is automatically generated. Do not edit!


config 32. 8.
width 20.

tree "Block - vcontrol"
; -------------------------------------------------------------------
; Begin Block - vcontrol
; -------------------------------------------------------------------
base D:0x70001400

tree "vcontrol0"
; --------------------- VC_VAVP1 member of vcontrol ---------------------

  group 0x0000++0x0003
    line.long 0x000 "VC_VAVP1, Negative droop clamp voltage, can be used to limit negative droop voltage independent of VOUT_MAX (e.g., set to 0 to disable negative droop).  Positive droop refers to decreasing voltage with positive IOUT, Negative droop refers increasing voltage with negative IOUT."
    textline "                   "
    hexmask.long.byte 0x0 0.--6. 0x1 0x0 " vc_vavp_clamp_neg         ,Negative droop clamp voltage, can be used to limit negative droop voltage independent of VOUT_MAX (e.g., set to 0 to disable negative droop).  Positive droop refers to decreasing voltage with positive IOUT, Negative droop refers increasing voltage with negative IOUT."
    textline "                   "
    hexmask.long.byte 0x0 7.--13. 0x1 0x0 " vc_vavp_clamp_pos         ,Positive droop clamp voltage,  can be used to limit positive droop voltage independent of VOUT_MIN.  Positive droop refers to decreasing voltage with positive IOUT, Negative droop refers increasing voltage with negative IOUT."
    textline "                   "
    hexmask.long.byte 0x0 14.--18. 0x1 0x0 " vc_vavp_kfp               ,LPF coefficient for  high  BW filter applied to the negative and VOUT_DROOP segments, set to all 1's to bypass. "
    textline "                   "
    hexmask.long.byte 0x0 19.--23. 0x1 0x0 " vc_vavp_kfp_lobw          ,LPF coefficient for  low  BW filter applied to the higher gain segments 2 and 3, set to all 1's to bypass. "

; --------------------- VC_VRAMP1 member of vcontrol ---------------------

  group 0x0004++0x0003
    line.long 0x000 "VC_VRAMP1, Ramp target value.  Note that while digitally this command can handle a wider range, the target value is limited to 2.1V by the analog circuitry. Computed from PMBus commands as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--14. 0x1 0x0 " vc_vramp_target           ,Ramp target value.  Note that while digitally this command can handle a wider range, the target value is limited to 2.1V by the analog circuitry. Computed from PMBus commands as follows: "
    textline "                   "
    hexmask.long.byte 0x0 15.--22. 0x1 0x0 " vc_vramp_target_window    ,Ramp target window, used to define interupt prior to reaching ramp target (e.g., during soft-start may be used to enable SR's prior to reaching final target)."
    textline "                   "
    hexmask.long.byte 0x0 23.--23. 0x1 0x0 " vc_vramp_load_immediate   ,Immediately loads vc_vramp_target into ramp output whigh.  Otherwise the ramp output is slewed to vc_vramp_target at a rate determined by vc_vramp_tstep.  The typical use for this field is during prebias startup.  The prebias voltage can be immediately loaded into the ramp to define the ramp start voltage then the target voltage (e.g., VOUT_COMMAND) can be set on vc_vramp_target with load_immediate set low to slew to the final voltage. "
    textline "                   "
    hexmask.long.byte 0x0 24.--24. 0x1 0x0 " vc_vramp_on               ,When high, indicates ramp should respond to target changes and that that loop is actively regulating.  Note: in addition to vcontrol, this signal is used by the PID, PWM and current estimator as an indication that we are actively regulating the output."

; --------------------- VC_VRAMP2 member of vcontrol ---------------------

  group 0x0008++0x0003
    line.long 0x000 "VC_VRAMP2, Ramp time step, defines voltage ramp slew rate. Computed from PMBus commands as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " vc_vramp_tstep            ,Ramp time step, defines voltage ramp slew rate. Computed from PMBus commands as follows: "

; --------------------- VC_VAVP2 member of vcontrol ---------------------

  group 0x000C++0x0003
    line.long 0x000 "VC_VAVP2, Total current offset term applied to Droop computations only.  Allows FW to apply offset to HW computed current."
    textline "                   "
    hexmask.long.word 0x0 0.--12. 0x1 0x0 " vc_vavp_itot_delta        ,Total current offset term applied to Droop computations only.  Allows FW to apply offset to HW computed current."

; --------------------- VC_VAVP3 member of vcontrol ---------------------

  group 0x0010++0x0003
    line.long 0x000 "VC_VAVP3, Loadline (droop) resistance, LSB=1mOhm / 2^7. "
    textline "                   "
    hexmask.long.word 0x0 0.--10. 0x1 0x0 " vc_vavp_rll               ,Loadline (droop) resistance, LSB=1mOhm / 2^7. "

; --------------------- VC_VRAMP3 member of vcontrol ---------------------

  group 0x0014++0x0003
    line.long 0x000 "VC_VRAMP3, Vcontrol output offset adjust Computed from PMBus commands as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--12. 0x1 0x0 " vc_vcontrol_delta         ,Vcontrol output offset adjust Computed from PMBus commands as follows: "

; -------------------- VC_MIN_MAX member of vcontrol --------------------

  group 0x0018++0x0003
    line.long 0x000 "VC_MIN_MAX, Vout max limit Computed from PMBus commands as follows: "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " vc_vcontrol_vout_max      ,Vout max limit Computed from PMBus commands as follows: "
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " vc_vcontrol_vout_min      ,Vout min limit Computed from PMBus commands as follows: "

; --------------------- VC_VAVP4 member of vcontrol ---------------------

  group 0x001C++0x0003
    line.long 0x000 "VC_VAVP4, Loadline (droop) resistance when load current is negative, LSB=1mOhm / 2^7. Computed from PMBus commands as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--10. 0x1 0x0 " vc_vavp_rll_neg           ,Loadline (droop) resistance when load current is negative, LSB=1mOhm / 2^7. Computed from PMBus commands as follows: "

; ---------------------- VC_IRQ member of vcontrol ----------------------

  group 0x0020++0x0003
    line.long 0x000 "VC_IRQ, Interrupt enable for Vcontrol.  When the bit indicated is high, the corresponding signal is enabled to generate an interrupt. "
    textline "                   "
    hexmask.long.byte 0x0 0.--1. 0x1 0x0 " vc_vcontrol_irq_en        ,Interrupt enable for Vcontrol.  When the bit indicated is high, the corresponding signal is enabled to generate an interrupt. "

; ----------------- VC_IRQ_STAT_FLAG member of vcontrol -----------------

  rgroup 0x0024++0x0003
    line.long 0x000 "VC_IRQ_STAT_FLAG, Interrupt status for Vcontrol. "
    textline "                   "
    hexmask.long.byte 0x0 0.--1. 0x1 0x0 " vc_vcontrol_irq_stat      ,Interrupt status for Vcontrol. "
    textline "                   "
    hexmask.long.byte 0x0 2.--2. 0x1 0x0 " vc_over_vout_max          ,Vout max status flag "
    textline "                   "
    hexmask.long.byte 0x0 3.--3. 0x1 0x0 " vc_under_vout_min         ,Vout min status flag "
    textline "                   "
    hexmask.long.byte 0x0 4.--4. 0x1 0x0 " vc_vcontrol_at_target     ,Status flag indicating the vcontrol ramp is at the target voltage. "
    textline "                   "
    hexmask.long.byte 0x0 5.--5. 0x1 0x0 " vc_vcontrol_ramp_busy     ,Status flag indicating the vcontrol ramp is slewing (inverse of vc_vcontrol_at_target). "
    textline "                   "
    hexmask.long.byte 0x0 6.--6. 0x1 0x0 " vc_vcontrol_ramp_fall     ,Status flag indicating the vcontrol ramp is slewing in a falling direction. "
    textline "                   "
    hexmask.long.byte 0x0 7.--7. 0x1 0x0 " vc_vcontrol_ramp_rise     ,Status flag indicating the vcontrol ramp is slewing in a rising direction. "

; -------------------- VC_VCTRL_RD member of vcontrol --------------------

  rgroup 0x0028++0x0003
    line.long 0x000 "VC_VCTRL_RD, Vcontrol status register.  Reflects target voltage in ADC format including offsets, droop, etc.  Must be scaled by 1/VOUT_SCALE_LOOP to get real target output voltage."
    textline "                   "
    hexmask.long.word 0x0 0.--14. 0x1 0x0 " vc_vcontrol               ,Vcontrol status register.  Reflects target voltage in ADC format including offsets, droop, etc.  Must be scaled by 1/VOUT_SCALE_LOOP to get real target output voltage."

; --------------------- VC_VAVP5 member of vcontrol ---------------------

  group 0x002C++0x0003
    line.long 0x000 "VC_VAVP5, Loadline (droop) resistance when load current exceeds vc_vavp_ithr_seg2 Computed from PMBus commands as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--9. 0x1 0x0 " vc_vavp_rll_seg2          ,Loadline (droop) resistance when load current exceeds vc_vavp_ithr_seg2 Computed from PMBus commands as follows: "

; --------------------- VC_VAVP6 member of vcontrol ---------------------

  group 0x0030++0x0003
    line.long 0x000 "VC_VAVP6, Loadline (droop) resistance when load current exceeds vc_vavp_ithr_seg3 Computed from PMBus commands as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--9. 0x1 0x0 " vc_vavp_rll_seg3          ,Loadline (droop) resistance when load current exceeds vc_vavp_ithr_seg3 Computed from PMBus commands as follows: "

; --------------------- VC_VAVP7 member of vcontrol ---------------------

  group 0x0034++0x0003
    line.long 0x000 "VC_VAVP7, When load current is above vc_vavp_ithr_seg2 and less than or equal to vc_vavp_ithr_seg3 the loadline (droop) resistance will be defined by vc_vavp_rll_seg2.  Note that a setting of 0 will disable this segment. Computed from PMBus command as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--8. 0x1 0x0 " vc_vavp_ithr_seg2         ,When load current is above vc_vavp_ithr_seg2 and less than or equal to vc_vavp_ithr_seg3 the loadline (droop) resistance will be defined by vc_vavp_rll_seg2.  Note that a setting of 0 will disable this segment. Computed from PMBus command as follows: "

; --------------------- VC_VAVP8 member of vcontrol ---------------------

  group 0x0038++0x0003
    line.long 0x000 "VC_VAVP8, When load current is above vc_vavp_ithr_seg3 the loadline (droop) resistance will be defined by vc_vavp_rll_seg3.  Note that a setting of 0 will disable this segment. Computed from PMBus command as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--8. 0x1 0x0 " vc_vavp_ithr_seg3         ,When load current is above vc_vavp_ithr_seg3 the loadline (droop) resistance will be defined by vc_vavp_rll_seg3.  Note that a setting of 0 will disable this segment. Computed from PMBus command as follows: "

; --------------------- VC_VAVP9 member of vcontrol ---------------------

  group 0x003C++0x0003
    line.long 0x000 "VC_VAVP9, Total current replacement term.  Allows FW to override HW computed total current for Droop computation when selected by vc_vavp_itot_uc_sel."
    textline "                   "
    hexmask.long.word 0x0 0.--12. 0x1 0x0 " vc_vavp_itot_uc           ,Total current replacement term.  Allows FW to override HW computed total current for Droop computation when selected by vc_vavp_itot_uc_sel."
    textline "                   "
    hexmask.long.byte 0x0 13.--13. 0x1 0x0 " vc_vavp_itot_uc_sel       ,Selects total current used by AVP (Droop) function "

tree.end
base D:0x70001800

tree "vcontrol1"
; --------------------- VC_VAVP1 member of vcontrol ---------------------

  group 0x0000++0x0003
    line.long 0x000 "VC_VAVP1, Negative droop clamp voltage, can be used to limit negative droop voltage independent of VOUT_MAX (e.g., set to 0 to disable negative droop).  Positive droop refers to decreasing voltage with positive IOUT, Negative droop refers increasing voltage with negative IOUT."
    textline "                   "
    hexmask.long.byte 0x0 0.--6. 0x1 0x0 " vc_vavp_clamp_neg         ,Negative droop clamp voltage, can be used to limit negative droop voltage independent of VOUT_MAX (e.g., set to 0 to disable negative droop).  Positive droop refers to decreasing voltage with positive IOUT, Negative droop refers increasing voltage with negative IOUT."
    textline "                   "
    hexmask.long.byte 0x0 7.--13. 0x1 0x0 " vc_vavp_clamp_pos         ,Positive droop clamp voltage,  can be used to limit positive droop voltage independent of VOUT_MIN.  Positive droop refers to decreasing voltage with positive IOUT, Negative droop refers increasing voltage with negative IOUT."
    textline "                   "
    hexmask.long.byte 0x0 14.--18. 0x1 0x0 " vc_vavp_kfp               ,LPF coefficient for  high  BW filter applied to the negative and VOUT_DROOP segments, set to all 1's to bypass. "
    textline "                   "
    hexmask.long.byte 0x0 19.--23. 0x1 0x0 " vc_vavp_kfp_lobw          ,LPF coefficient for  low  BW filter applied to the higher gain segments 2 and 3, set to all 1's to bypass. "

; --------------------- VC_VRAMP1 member of vcontrol ---------------------

  group 0x0004++0x0003
    line.long 0x000 "VC_VRAMP1, Ramp target value.  Note that while digitally this command can handle a wider range, the target value is limited to 2.1V by the analog circuitry. Computed from PMBus commands as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--14. 0x1 0x0 " vc_vramp_target           ,Ramp target value.  Note that while digitally this command can handle a wider range, the target value is limited to 2.1V by the analog circuitry. Computed from PMBus commands as follows: "
    textline "                   "
    hexmask.long.byte 0x0 15.--22. 0x1 0x0 " vc_vramp_target_window    ,Ramp target window, used to define interupt prior to reaching ramp target (e.g., during soft-start may be used to enable SR's prior to reaching final target)."
    textline "                   "
    hexmask.long.byte 0x0 23.--23. 0x1 0x0 " vc_vramp_load_immediate   ,Immediately loads vc_vramp_target into ramp output whigh.  Otherwise the ramp output is slewed to vc_vramp_target at a rate determined by vc_vramp_tstep.  The typical use for this field is during prebias startup.  The prebias voltage can be immediately loaded into the ramp to define the ramp start voltage then the target voltage (e.g., VOUT_COMMAND) can be set on vc_vramp_target with load_immediate set low to slew to the final voltage. "
    textline "                   "
    hexmask.long.byte 0x0 24.--24. 0x1 0x0 " vc_vramp_on               ,When high, indicates ramp should respond to target changes and that that loop is actively regulating.  Note: in addition to vcontrol, this signal is used by the PID, PWM and current estimator as an indication that we are actively regulating the output."

; --------------------- VC_VRAMP2 member of vcontrol ---------------------

  group 0x0008++0x0003
    line.long 0x000 "VC_VRAMP2, Ramp time step, defines voltage ramp slew rate. Computed from PMBus commands as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--15. 0x1 0x0 " vc_vramp_tstep            ,Ramp time step, defines voltage ramp slew rate. Computed from PMBus commands as follows: "

; --------------------- VC_VAVP2 member of vcontrol ---------------------

  group 0x000C++0x0003
    line.long 0x000 "VC_VAVP2, Total current offset term applied to Droop computations only.  Allows FW to apply offset to HW computed current."
    textline "                   "
    hexmask.long.word 0x0 0.--12. 0x1 0x0 " vc_vavp_itot_delta        ,Total current offset term applied to Droop computations only.  Allows FW to apply offset to HW computed current."

; --------------------- VC_VAVP3 member of vcontrol ---------------------

  group 0x0010++0x0003
    line.long 0x000 "VC_VAVP3, Loadline (droop) resistance, LSB=1mOhm / 2^7. "
    textline "                   "
    hexmask.long.word 0x0 0.--10. 0x1 0x0 " vc_vavp_rll               ,Loadline (droop) resistance, LSB=1mOhm / 2^7. "

; --------------------- VC_VRAMP3 member of vcontrol ---------------------

  group 0x0014++0x0003
    line.long 0x000 "VC_VRAMP3, Vcontrol output offset adjust Computed from PMBus commands as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--12. 0x1 0x0 " vc_vcontrol_delta         ,Vcontrol output offset adjust Computed from PMBus commands as follows: "

; -------------------- VC_MIN_MAX member of vcontrol --------------------

  group 0x0018++0x0003
    line.long 0x000 "VC_MIN_MAX, Vout max limit Computed from PMBus commands as follows: "
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " vc_vcontrol_vout_max      ,Vout max limit Computed from PMBus commands as follows: "
    textline "                   "
    hexmask.long.byte 0x0 8.--15. 0x1 0x0 " vc_vcontrol_vout_min      ,Vout min limit Computed from PMBus commands as follows: "

; --------------------- VC_VAVP4 member of vcontrol ---------------------

  group 0x001C++0x0003
    line.long 0x000 "VC_VAVP4, Loadline (droop) resistance when load current is negative, LSB=1mOhm / 2^7. Computed from PMBus commands as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--10. 0x1 0x0 " vc_vavp_rll_neg           ,Loadline (droop) resistance when load current is negative, LSB=1mOhm / 2^7. Computed from PMBus commands as follows: "

; ---------------------- VC_IRQ member of vcontrol ----------------------

  group 0x0020++0x0003
    line.long 0x000 "VC_IRQ, Interrupt enable for Vcontrol.  When the bit indicated is high, the corresponding signal is enabled to generate an interrupt. "
    textline "                   "
    hexmask.long.byte 0x0 0.--1. 0x1 0x0 " vc_vcontrol_irq_en        ,Interrupt enable for Vcontrol.  When the bit indicated is high, the corresponding signal is enabled to generate an interrupt. "

; ----------------- VC_IRQ_STAT_FLAG member of vcontrol -----------------

  rgroup 0x0024++0x0003
    line.long 0x000 "VC_IRQ_STAT_FLAG, Interrupt status for Vcontrol. "
    textline "                   "
    hexmask.long.byte 0x0 0.--1. 0x1 0x0 " vc_vcontrol_irq_stat      ,Interrupt status for Vcontrol. "
    textline "                   "
    hexmask.long.byte 0x0 2.--2. 0x1 0x0 " vc_over_vout_max          ,Vout max status flag "
    textline "                   "
    hexmask.long.byte 0x0 3.--3. 0x1 0x0 " vc_under_vout_min         ,Vout min status flag "
    textline "                   "
    hexmask.long.byte 0x0 4.--4. 0x1 0x0 " vc_vcontrol_at_target     ,Status flag indicating the vcontrol ramp is at the target voltage. "
    textline "                   "
    hexmask.long.byte 0x0 5.--5. 0x1 0x0 " vc_vcontrol_ramp_busy     ,Status flag indicating the vcontrol ramp is slewing (inverse of vc_vcontrol_at_target). "
    textline "                   "
    hexmask.long.byte 0x0 6.--6. 0x1 0x0 " vc_vcontrol_ramp_fall     ,Status flag indicating the vcontrol ramp is slewing in a falling direction. "
    textline "                   "
    hexmask.long.byte 0x0 7.--7. 0x1 0x0 " vc_vcontrol_ramp_rise     ,Status flag indicating the vcontrol ramp is slewing in a rising direction. "

; -------------------- VC_VCTRL_RD member of vcontrol --------------------

  rgroup 0x0028++0x0003
    line.long 0x000 "VC_VCTRL_RD, Vcontrol status register.  Reflects target voltage in ADC format including offsets, droop, etc.  Must be scaled by 1/VOUT_SCALE_LOOP to get real target output voltage."
    textline "                   "
    hexmask.long.word 0x0 0.--14. 0x1 0x0 " vc_vcontrol               ,Vcontrol status register.  Reflects target voltage in ADC format including offsets, droop, etc.  Must be scaled by 1/VOUT_SCALE_LOOP to get real target output voltage."

; --------------------- VC_VAVP5 member of vcontrol ---------------------

  group 0x002C++0x0003
    line.long 0x000 "VC_VAVP5, Loadline (droop) resistance when load current exceeds vc_vavp_ithr_seg2 Computed from PMBus commands as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--9. 0x1 0x0 " vc_vavp_rll_seg2          ,Loadline (droop) resistance when load current exceeds vc_vavp_ithr_seg2 Computed from PMBus commands as follows: "

; --------------------- VC_VAVP6 member of vcontrol ---------------------

  group 0x0030++0x0003
    line.long 0x000 "VC_VAVP6, Loadline (droop) resistance when load current exceeds vc_vavp_ithr_seg3 Computed from PMBus commands as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--9. 0x1 0x0 " vc_vavp_rll_seg3          ,Loadline (droop) resistance when load current exceeds vc_vavp_ithr_seg3 Computed from PMBus commands as follows: "

; --------------------- VC_VAVP7 member of vcontrol ---------------------

  group 0x0034++0x0003
    line.long 0x000 "VC_VAVP7, When load current is above vc_vavp_ithr_seg2 and less than or equal to vc_vavp_ithr_seg3 the loadline (droop) resistance will be defined by vc_vavp_rll_seg2.  Note that a setting of 0 will disable this segment. Computed from PMBus command as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--8. 0x1 0x0 " vc_vavp_ithr_seg2         ,When load current is above vc_vavp_ithr_seg2 and less than or equal to vc_vavp_ithr_seg3 the loadline (droop) resistance will be defined by vc_vavp_rll_seg2.  Note that a setting of 0 will disable this segment. Computed from PMBus command as follows: "

; --------------------- VC_VAVP8 member of vcontrol ---------------------

  group 0x0038++0x0003
    line.long 0x000 "VC_VAVP8, When load current is above vc_vavp_ithr_seg3 the loadline (droop) resistance will be defined by vc_vavp_rll_seg3.  Note that a setting of 0 will disable this segment. Computed from PMBus command as follows: "
    textline "                   "
    hexmask.long.word 0x0 0.--8. 0x1 0x0 " vc_vavp_ithr_seg3         ,When load current is above vc_vavp_ithr_seg3 the loadline (droop) resistance will be defined by vc_vavp_rll_seg3.  Note that a setting of 0 will disable this segment. Computed from PMBus command as follows: "

; --------------------- VC_VAVP9 member of vcontrol ---------------------

  group 0x003C++0x0003
    line.long 0x000 "VC_VAVP9, Total current replacement term.  Allows FW to override HW computed total current for Droop computation when selected by vc_vavp_itot_uc_sel."
    textline "                   "
    hexmask.long.word 0x0 0.--12. 0x1 0x0 " vc_vavp_itot_uc           ,Total current replacement term.  Allows FW to override HW computed total current for Droop computation when selected by vc_vavp_itot_uc_sel."
    textline "                   "
    hexmask.long.byte 0x0 13.--13. 0x1 0x0 " vc_vavp_itot_uc_sel       ,Selects total current used by AVP (Droop) function "

tree.end

; -------------------------------------------------------------------
; End Block - vcontrol
; -------------------------------------------------------------------
tree.end
; @file:      vsen.per
; Chip name:  SHASTA
; Module:     vsen
; 
; Generated by the pmm metagen library.
;
; ===================================================================
; Copyright (C) 2018 Infineon Technologies AG
; All rights reserved.
; ===================================================================
;
; ===================================================================
; This document contains proprietary information. Passing on and
; copying of this document, and communication of its contents is not
; permitted without prior written authorisation.
; ===================================================================

; This file is automatically generated. Do not edit!


config 32. 8.
width 20.

tree "Block - vsen"
; -------------------------------------------------------------------
; Begin Block - vsen
; -------------------------------------------------------------------
base D:0x70000800

tree "vsen0"
; ------------------------- VSP1 member of vsen -------------------------

  group 0x0000++0x0003
    line.long 0x000 "VSP1, Verrn clamp threshold at PID input.  Note 40mV offset at code 0."
    textline "                   "
    hexmask.long.byte 0x0 0.--2. 0x1 0x0 " vsp_verrn_clamp_thresh    ,Verrn clamp threshold at PID input.  Note 40mV offset at code 0."
    textline "                   "
    hexmask.long.byte 0x0 3.--5. 0x1 0x0 " vsp_verrn_large_thresh    ,Verrn large error detect threshold.  Currently unused."
    textline "                   "
    hexmask.long.byte 0x0 6.--6. 0x1 0x0 " vsp_en_fe_comp_lp         ,Voltage sense front end stress compensation enable "
    textline "                   "
    hexmask.long.word 0x0 7.--16. 0x1 0x0 " vsp_fe_count_thr          ,Defines variable part of voltage sense front end stress compensation period."
    textline "                   "
    hexmask.long.byte 0x0 17.--17. 0x1 0x0 " vsp_mode_fe_1p25m         ,Defines voltage sense front end stress compensation DAC LSB "
    textline "                   "
    hexmask.long.byte 0x0 18.--22. 0x1 0x0 " vsp_count_fe_cmp          ,Defines the number of consecutive voltage sense front end compensation cycles with the comparator in the same polarity required to increment or decrement the FE compensation DAC."

; ------------------------- VSP2 member of vsen -------------------------

  group 0x0004++0x0003
    line.long 0x000 "VSP2, When high, holds the previous input from the Voltage Sense ADC."
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " vsp_adc_blank             ,When high, holds the previous input from the Voltage Sense ADC."

; ------------------------- VSP3 member of vsen -------------------------

  group 0x0008++0x0003
    line.long 0x000 "VSP3, Open sense protection fault comparator enable.  Controlled by FW. "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " vsp_osp_en                ,Open sense protection fault comparator enable.  Controlled by FW. "

; ------------------------- VSP4 member of vsen -------------------------

  group 0x000C++0x0003
    line.long 0x000 "VSP4, Open sense protection fault comparator threshold."
    textline "                   "
    hexmask.long.word 0x0 0.--11. 0x1 0x0 " vsp_osp_thresh            ,Open sense protection fault comparator threshold."

tree.end
base D:0x70000C00

tree "vsen1"
; ------------------------- VSP1 member of vsen -------------------------

  group 0x0000++0x0003
    line.long 0x000 "VSP1, Verrn clamp threshold at PID input.  Note 40mV offset at code 0."
    textline "                   "
    hexmask.long.byte 0x0 0.--2. 0x1 0x0 " vsp_verrn_clamp_thresh    ,Verrn clamp threshold at PID input.  Note 40mV offset at code 0."
    textline "                   "
    hexmask.long.byte 0x0 3.--5. 0x1 0x0 " vsp_verrn_large_thresh    ,Verrn large error detect threshold.  Currently unused."
    textline "                   "
    hexmask.long.byte 0x0 6.--6. 0x1 0x0 " vsp_en_fe_comp_lp         ,Voltage sense front end stress compensation enable "
    textline "                   "
    hexmask.long.word 0x0 7.--16. 0x1 0x0 " vsp_fe_count_thr          ,Defines variable part of voltage sense front end stress compensation period."
    textline "                   "
    hexmask.long.byte 0x0 17.--17. 0x1 0x0 " vsp_mode_fe_1p25m         ,Defines voltage sense front end stress compensation DAC LSB "
    textline "                   "
    hexmask.long.byte 0x0 18.--22. 0x1 0x0 " vsp_count_fe_cmp          ,Defines the number of consecutive voltage sense front end compensation cycles with the comparator in the same polarity required to increment or decrement the FE compensation DAC."

; ------------------------- VSP2 member of vsen -------------------------

  group 0x0004++0x0003
    line.long 0x000 "VSP2, When high, holds the previous input from the Voltage Sense ADC."
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " vsp_adc_blank             ,When high, holds the previous input from the Voltage Sense ADC."

; ------------------------- VSP3 member of vsen -------------------------

  group 0x0008++0x0003
    line.long 0x000 "VSP3, Open sense protection fault comparator enable.  Controlled by FW. "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " vsp_osp_en                ,Open sense protection fault comparator enable.  Controlled by FW. "

; ------------------------- VSP4 member of vsen -------------------------

  group 0x000C++0x0003
    line.long 0x000 "VSP4, Open sense protection fault comparator threshold."
    textline "                   "
    hexmask.long.word 0x0 0.--11. 0x1 0x0 " vsp_osp_thresh            ,Open sense protection fault comparator threshold."

tree.end
base D:0x70001000

tree "vsen2"
; ------------------------- VSP1 member of vsen -------------------------

  group 0x0000++0x0003
    line.long 0x000 "VSP1, Verrn clamp threshold at PID input.  Note 40mV offset at code 0."
    textline "                   "
    hexmask.long.byte 0x0 0.--2. 0x1 0x0 " vsp_verrn_clamp_thresh    ,Verrn clamp threshold at PID input.  Note 40mV offset at code 0."
    textline "                   "
    hexmask.long.byte 0x0 3.--5. 0x1 0x0 " vsp_verrn_large_thresh    ,Verrn large error detect threshold.  Currently unused."
    textline "                   "
    hexmask.long.byte 0x0 6.--6. 0x1 0x0 " vsp_en_fe_comp_lp         ,Voltage sense front end stress compensation enable "
    textline "                   "
    hexmask.long.word 0x0 7.--16. 0x1 0x0 " vsp_fe_count_thr          ,Defines variable part of voltage sense front end stress compensation period."
    textline "                   "
    hexmask.long.byte 0x0 17.--17. 0x1 0x0 " vsp_mode_fe_1p25m         ,Defines voltage sense front end stress compensation DAC LSB "
    textline "                   "
    hexmask.long.byte 0x0 18.--22. 0x1 0x0 " vsp_count_fe_cmp          ,Defines the number of consecutive voltage sense front end compensation cycles with the comparator in the same polarity required to increment or decrement the FE compensation DAC."

; ------------------------- VSP2 member of vsen -------------------------

  group 0x0004++0x0003
    line.long 0x000 "VSP2, When high, holds the previous input from the Voltage Sense ADC."
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " vsp_adc_blank             ,When high, holds the previous input from the Voltage Sense ADC."

; ------------------------- VSP3 member of vsen -------------------------

  group 0x0008++0x0003
    line.long 0x000 "VSP3, Open sense protection fault comparator enable.  Controlled by FW. "
    textline "                   "
    hexmask.long.byte 0x0 0.--0. 0x1 0x0 " vsp_osp_en                ,Open sense protection fault comparator enable.  Controlled by FW. "

; ------------------------- VSP4 member of vsen -------------------------

  group 0x000C++0x0003
    line.long 0x000 "VSP4, Open sense protection fault comparator threshold."
    textline "                   "
    hexmask.long.word 0x0 0.--11. 0x1 0x0 " vsp_osp_thresh            ,Open sense protection fault comparator threshold."

tree.end

; -------------------------------------------------------------------
; End Block - vsen
; -------------------------------------------------------------------
tree.end
; @file:      wdt.per
; Chip name:  SHASTA
; Module:     wdt
; 
; Generated by the pmm metagen library.
;
; ===================================================================
; Copyright (C) 2018 Infineon Technologies AG
; All rights reserved.
; ===================================================================
;
; ===================================================================
; This document contains proprietary information. Passing on and
; copying of this document, and communication of its contents is not
; permitted without prior written authorisation.
; ===================================================================

; This file is automatically generated. Do not edit!


config 32. 8.
width 20.

tree "Block - wdt"
; -------------------------------------------------------------------
; Begin Block - wdt
; -------------------------------------------------------------------
base D:0x60000000

tree "wdt"
; ------------------------ WDOGLOAD member of wdt ------------------------

  group 0x0000++0x0003
    line.long 0x000 "WDOGLOAD, Watchdog Load Register"
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " LOAD                      ,Load Counter Value"

; ----------------------- WDOGVALUE member of wdt -----------------------

  rgroup 0x0004++0x0003
    line.long 0x000 "WDOGVALUE, Watchdog Value Register"
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " VALUE                     ,Current Counter Value"

; ---------------------- WDOGCONTROL member of wdt ----------------------

  group 0x0008++0x0003
    line.long 0x000 "WDOGCONTROL, Watchdog Control Register"
    textline "                   "
    bitfld.long 0x0 0. " INTEN                     ,Interrupt Enable" "S0 (0),S1 (1)"
    textline "                   "
    bitfld.long 0x0 1. " RESEN                     ,Watchdog Reset Output Enable" "S0 (0),S1 (1)"

; ----------------------- WDOGINTCLR member of wdt -----------------------

  group 0x000C++0x0003
    line.long 0x000 "WDOGINTCLR, Watchdog Clear Interrupt Register"
    textline "                   "
    hexmask.long.long 0x0 0.--31. 0x1 0x0 " INTCLR                    ,Interrupt Clear"

; ------------------------ WDOGRIS member of wdt ------------------------

  rgroup 0x0010++0x0003
    line.long 0x000 "WDOGRIS, Watchdog Raw Interrupt Status Register"
    textline "                   "
    bitfld.long 0x0 0. " RAWINT                    ,Raw Interrupt Status" "S0 (0),S1 (1)"

; ------------------------ WDOGMIS member of wdt ------------------------

  rgroup 0x0014++0x0003
    line.long 0x000 "WDOGMIS, Watchdog Masked Interrupt Status Register"
    textline "                   "
    bitfld.long 0x0 0. " INTMASK                   ,Masked Interrupt Status" "S0 (0),S1 (1)"

; ------------------------ WDOGLOCK member of wdt ------------------------

  group 0x0C00++0x0003
    line.long 0x000 "WDOGLOCK, Wacthdog Lock Register"
    textline "                   "
    bitfld.long 0x0 0. " LOCKEN                    ,Register Write Protection Control" "S0 (0),S1 (1)"

; ------------------------ WDOGITCR member of wdt ------------------------

  group 0x0F00++0x0003
    line.long 0x000 "WDOGITCR, Watchdog Integration Test Control Register"
    textline "                   "
    bitfld.long 0x0 0. " ITME                      ,Integration Test Mode Enable" "S0 (0),S1 (1)"

; ------------------------ WDOGITOP member of wdt ------------------------

  group 0x0F04++0x0003
    line.long 0x000 "WDOGITOP, Watchdog Integration Test Output Set Register"
    textline "                   "
    bitfld.long 0x0 0. " ITRES                     ,Integration Test WDOGRES Value" "S0 (0),S1 (1)"
    textline "                   "
    bitfld.long 0x0 1. " ITINT                     ,Integration Test WDOGINT Value" "S0 (0),S1 (1)"

; --------------------- WDOGPERIPHID0 member of wdt ---------------------

  rgroup 0x0FE0++0x0003
    line.long 0x000 "WDOGPERIPHID0, WDT Identification Register 0"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " PartNumber0               ,Part Number 0"

; --------------------- WDOGPERIPHID1 member of wdt ---------------------

  rgroup 0x0FE4++0x0003
    line.long 0x000 "WDOGPERIPHID1, WDT Identification Register 1"
    textline "                   "
    hexmask.long.byte 0x0 0.--3. 0x1 0x0 " PartNumber1               ,Part Number 1"
    textline "                   "
    hexmask.long.byte 0x0 4.--7. 0x1 0x0 " Designer0                 ,Designer Number 0"

; --------------------- WDOGPERIPHID2 member of wdt ---------------------

  rgroup 0x0FE8++0x0003
    line.long 0x000 "WDOGPERIPHID2, WDT Identification Register 2"
    textline "                   "
    hexmask.long.byte 0x0 0.--3. 0x1 0x0 " Designer1                 ,Designer Number 1"
    textline "                   "
    hexmask.long.byte 0x0 4.--7. 0x1 0x0 " Revision                  ,Revision Number"

; --------------------- WDOGPERIPHID3 member of wdt ---------------------

  rgroup 0x0FEC++0x0003
    line.long 0x000 "WDOGPERIPHID3, WDT Identification Register 3"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " Configuration             ,Configuration Number"

; ---------------------- WDOGPCELLID0 member of wdt ----------------------

  rgroup 0x0FF0++0x0003
    line.long 0x000 "WDOGPCELLID0, PrimeCell Identification Register 0"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " WDOGPCELLID0              ,Cell Identification Number 0"

; ---------------------- WDOGPCELLID1 member of wdt ----------------------

  rgroup 0x0FF4++0x0003
    line.long 0x000 "WDOGPCELLID1, PrimeCell Identification Register 1"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " WDOGPCELLID1              ,Cell Identification Number 1"

; ---------------------- WDOGPCELLID2 member of wdt ----------------------

  rgroup 0x0FF8++0x0003
    line.long 0x000 "WDOGPCELLID2, PrimeCell Identification Register 2"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " WDOGPCELLID2              ,Cell Identification Number 2"

; ---------------------- WDOGPCELLID3 member of wdt ----------------------

  rgroup 0x0FFC++0x0003
    line.long 0x000 "WDOGPCELLID3, PrimeCell Identification Register 3"
    textline "                   "
    hexmask.long.byte 0x0 0.--7. 0x1 0x0 " WDOGPCELLID3              ,Cell Identification Number 3"

tree.end

; -------------------------------------------------------------------
; End Block - wdt
; -------------------------------------------------------------------
tree.end
                                                                                                                                                                                                        
; CortexM1 On-Chip Peripherals
; --------------------------------------------------
; Core          : ARM6-M
; Manufacturer  : ARM
;
; Author        : MPO
; Date          : 29.02.2008
; Doc           : Cortex-M1_TechnicalReferenceManualRevC_r0p1-01rel0
; Status        : released
; --------------------------------------------------
; CortexM1 @(#) Feb 29 2008


config 16. 8.

width 0xe

tree "Nested Vectored Interrupt Controller"
 base d:0xe000e000
width 0xf

group.long 0x100++0x03
 line.long 0x00 "SET/CLREN,Interrupt Set/Clear Enable Register"
   setclrfld.long 0x00 31. 0x00 31. 0x80 31. " SET/CLRENA31 ,Interrupt Set/Clear Enable Bit" "Disabled,Enabled"
   setclrfld.long 0x00 30. 0x00 30. 0x80 30. "     SET/CLRENA30 ,Interrupt Set/Clear Enable Bit" "Disabled,Enabled"
   setclrfld.long 0x00 29. 0x00 29. 0x80 29. "     SET/CLRENA29 ,Interrupt Set/Clear Enable Bit" "Disabled,Enabled"
  textline "                        "
   setclrfld.long 0x00 28. 0x00 28. 0x80 28. " SET/CLRENA28 ,Interrupt Set/Clear Enable Bit" "Disabled,Enabled"
   setclrfld.long 0x00 27. 0x00 27. 0x80 27. "     SET/CLRENA27 ,Interrupt Set/Clear Enable Bit" "Disabled,Enabled"
   setclrfld.long 0x00 26. 0x00 26. 0x80 26. "     SET/CLRENA26 ,Interrupt Set/Clear Enable Bit" "Disabled,Enabled"
  textline "                        "
   setclrfld.long 0x00 25. 0x00 25. 0x80 25. " SET/CLRENA25 ,Interrupt Set/Clear Enable Bit" "Disabled,Enabled"
   setclrfld.long 0x00 24. 0x00 24. 0x80 24. "     SET/CLRENA24 ,Interrupt Set/Clear Enable Bit" "Disabled,Enabled"
   setclrfld.long 0x00 23. 0x00 23. 0x80 23. "     SET/CLRENA23 ,Interrupt Set/Clear Enable Bit" "Disabled,Enabled"
  textline "                        "
   setclrfld.long 0x00 22. 0x00 22. 0x80 22. " SET/CLRENA22 ,Interrupt Set/Clear Enable Bit" "Disabled,Enabled"
   setclrfld.long 0x00 21. 0x00 21. 0x80 21. "     SET/CLRENA21 ,Interrupt Set/Clear Enable Bit" "Disabled,Enabled"
   setclrfld.long 0x00 20. 0x00 20. 0x80 20. "     SET/CLRENA20 ,Interrupt Set/Clear Enable Bit" "Disabled,Enabled"
  textline "                        "
   setclrfld.long 0x00 19. 0x00 19. 0x80 19. " SET/CLRENA19 ,Interrupt Set/Clear Enable Bit" "Disabled,Enabled"
   setclrfld.long 0x00 18. 0x00 18. 0x80 18. "     SET/CLRENA18 ,Interrupt Set/Clear Enable Bit" "Disabled,Enabled"
   setclrfld.long 0x00 17. 0x00 17. 0x80 17. "     SET/CLRENA17 ,Interrupt Set/Clear Enable Bit" "Disabled,Enabled"
  textline "                        "
   setclrfld.long 0x00 16. 0x00 16. 0x80 16. " SET/CLRENA16 ,Interrupt Set/Clear Enable Bit" "Disabled,Enabled"
   setclrfld.long 0x00 15. 0x00 15. 0x80 15. "     SET/CLRENA15 ,Interrupt Set/Clear Enable Bit" "Disabled,Enabled"
   setclrfld.long 0x00 14. 0x00 14. 0x80 14. "     SET/CLRENA14 ,Interrupt Set/Clear Enable Bit" "Disabled,Enabled"
  textline "                        "
   setclrfld.long 0x00 13. 0x00 13. 0x80 13. " SET/CLRENA13 ,Interrupt Set/Clear Enable Bit" "Disabled,Enabled"
   setclrfld.long 0x00 12. 0x00 12. 0x80 12. "     SET/CLRENA12 ,Interrupt Set/Clear Enable Bit" "Disabled,Enabled"
   setclrfld.long 0x00 11. 0x00 11. 0x80 11. "     SET/CLRENA11 ,Interrupt Set/Clear Enable Bit" "Disabled,Enabled"
  textline "                        "
   setclrfld.long 0x00 10. 0x00 10. 0x80 10. " SET/CLRENA10 ,Interrupt Set/Clear Enable Bit" "Disabled,Enabled"
   setclrfld.long 0x00 9. 0x00 9. 0x80 9. "     SET/CLRENA9  ,Interrupt Set/Clear Enable Bit" "Disabled,Enabled"
   setclrfld.long 0x00 8. 0x00 8. 0x80 8. "     SET/CLRENA8  ,Interrupt Set/Clear Enable Bit" "Disabled,Enabled"
  textline "                        "
   setclrfld.long 0x00 7. 0x00 7. 0x80 7. " SET/CLRENA7  ,Interrupt Set/Clear Enable Bit" "Disabled,Enabled"
   setclrfld.long 0x00 6. 0x00 6. 0x80 6. "     SET/CLRENA6  ,Interrupt Set/Clear Enable Bit" "Disabled,Enabled"
   setclrfld.long 0x00 5. 0x00 5. 0x80 5. "     SET/CLRENA5  ,Interrupt Set/Clear Enable Bit" "Disabled,Enabled"
  textline "                        "
   setclrfld.long 0x00 4. 0x00 4. 0x80 4. " SET/CLRENA4  ,Interrupt Set/Clear Enable Bit" "Disabled,Enabled"
   setclrfld.long 0x00 3. 0x00 3. 0x80 3. "     SET/CLRENA3  ,Interrupt Set/Clear Enable Bit" "Disabled,Enabled"
   setclrfld.long 0x00 2. 0x00 2. 0x80 2. "     SET/CLRENA2  ,Interrupt Set/Clear Enable Bit" "Disabled,Enabled"
  textline "                        "
   setclrfld.long 0x00 1. 0x00 1. 0x80 1. " SET/CLRENA1  ,Interrupt Set/Clear Enable Bit" "Disabled,Enabled"
   setclrfld.long 0x00 0. 0x00 0. 0x80 0. "     SET/CLRENA0  ,Interrupt Set/Clear Enable Bit" "Disabled,Enabled"

 
group.long 0x200++0x03 
 line.long 0x00 "SET/CLRPEN,Interrupt Set/Clear Pending Register"
  setclrfld.long 0x00 31. 0x00 31. 0x80 31. " SET/CLRPEN31 ,Interrupt Set/Clear Pending" "Not pending,Pending"
  setclrfld.long 0x00 30. 0x00 30. 0x80 30. "  SET/CLRPEN30 ,Interrupt Set/Clear Pending" "Not pending,Pending"
  setclrfld.long 0x00 29. 0x00 29. 0x80 29. "  SET/CLRPEN29 ,Interrupt Set/Clear Pending" "Not pending,Pending"
  textline "                        "
  setclrfld.long 0x00 28. 0x00 28. 0x80 28. " SET/CLRPEN28 ,Interrupt Set/Clear Pending" "Not pending,Pending"
  setclrfld.long 0x00 27. 0x00 27. 0x80 27. "  SET/CLRPEN27 ,Interrupt Set/Clear Pending" "Not pending,Pending"
  setclrfld.long 0x00 26. 0x00 26. 0x80 26. "  SET/CLRPEN26 ,Interrupt Set/Clear Pending" "Not pending,Pending"
  textline "                        "
  setclrfld.long 0x00 25. 0x00 25. 0x80 25. " SET/CLRPEN25 ,Interrupt Set/Clear Pending" "Not pending,Pending"
  setclrfld.long 0x00 24. 0x00 24. 0x80 24. "  SET/CLRPEN24 ,Interrupt Set/Clear Pending" "Not pending,Pending"
  setclrfld.long 0x00 23. 0x00 23. 0x80 23. "  SET/CLRPEN23 ,Interrupt Set/Clear Pending" "Not pending,Pending"
  textline "                        "
  setclrfld.long 0x00 22. 0x00 22. 0x80 22. " SET/CLRPEN22 ,Interrupt Set/Clear Pending" "Not pending,Pending"
  setclrfld.long 0x00 21. 0x00 21. 0x80 21. "  SET/CLRPEN21 ,Interrupt Set/Clear Pending" "Not pending,Pending"
  setclrfld.long 0x00 20. 0x00 20. 0x80 20. "  SET/CLRPEN20 ,Interrupt Set/Clear Pending" "Not pending,Pending"
  textline "                        "
  setclrfld.long 0x00 19. 0x00 19. 0x80 19. " SET/CLRPEN19 ,Interrupt Set/Clear Pending" "Not pending,Pending"
  setclrfld.long 0x00 18. 0x00 18. 0x80 18. "  SET/CLRPEN18 ,Interrupt Set/Clear Pending" "Not pending,Pending"
  setclrfld.long 0x00 17. 0x00 17. 0x80 17. "  SET/CLRPEN17 ,Interrupt Set/Clear Pending" "Not pending,Pending"
  textline "                        "
  setclrfld.long 0x00 16. 0x00 16. 0x80 16. " SET/CLRPEN16 ,Interrupt Set/Clear Pending" "Not pending,Pending"
  setclrfld.long 0x00 15. 0x00 15. 0x80 15. "  SET/CLRPEN15 ,Interrupt Set/Clear Pending" "Not pending,Pending"
  setclrfld.long 0x00 14. 0x00 14. 0x80 14. "  SET/CLRPEN14 ,Interrupt Set/Clear Pending" "Not pending,Pending"
  textline "                        "
  setclrfld.long 0x00 13. 0x00 13. 0x80 13. " SET/CLRPEN13 ,Interrupt Set/Clear Pending" "Not pending,Pending"
  setclrfld.long 0x00 12. 0x00 12. 0x80 12. "  SET/CLRPEN12 ,Interrupt Set/Clear Pending" "Not pending,Pending"
  setclrfld.long 0x00 11. 0x00 11. 0x80 11. "  SET/CLRPEN11 ,Interrupt Set/Clear Pending" "Not pending,Pending"
  textline "                        "
  setclrfld.long 0x00 10. 0x00 10. 0x80 10. " SET/CLRPEN10 ,Interrupt Set/Clear Pending" "Not pending,Pending"
  setclrfld.long 0x00 9. 0x00 9. 0x80 9. "  SET/CLRPEN9  ,Interrupt Set/Clear Pending" "Not pending,Pending"
  setclrfld.long 0x00 8. 0x00 8. 0x80 8. "  SET/CLRPEN8  ,Interrupt Set/Clear Pending" "Not pending,Pending"
  textline "                        "
  setclrfld.long 0x00 7. 0x00 7. 0x80 7. " SET/CLRPEN7  ,Interrupt Set/Clear Pending" "Not pending,Pending"
  setclrfld.long 0x00 6. 0x00 6. 0x80 6. "  SET/CLRPEN6  ,Interrupt Set/Clear Pending" "Not pending,Pending"
  setclrfld.long 0x00 5. 0x00 5. 0x80 5. "  SET/CLRPEN5  ,Interrupt Set/Clear Pending" "Not pending,Pending"
  textline "                        "
  setclrfld.long 0x00 4. 0x00 4. 0x80 4. " SET/CLRPEN4  ,Interrupt Set/Clear Pending" "Not pending,Pending"
  setclrfld.long 0x00 3. 0x00 3. 0x80 3. "  SET/CLRPEN3  ,Interrupt Set/Clear Pending" "Not pending,Pending"
  setclrfld.long 0x00 2. 0x00 2. 0x80 2. "  SET/CLRPEN2  ,Interrupt Set/Clear Pending" "Not pending,Pending"
  textline "                        "  
  setclrfld.long 0x00 1. 0x00 1. 0x80 1. " SET/CLRPEN1  ,Interrupt Set/Clear Pending" "Not pending,Pending"
  setclrfld.long 0x00 0. 0x00 0. 0x80 0. "  SET/CLRPEN0  ,Interrupt Set/Clear Pending" "Not pending,Pending"
  
 
tree "Interrupt Priority Registers"
 base d:0xe000e000
width 7.

group.long 0x400++0x41f

 line.long 0x0 "INT0,Interrupt Priority Register"
  bitfld.long 0x0 30.--31. " IP_3  ,Priority of interrupt 3" "0,1,2,3"
  bitfld.long 0x0 22.--23. "  IP_2  ,Priority of interrupt 2" "0,1,2,3"
  bitfld.long 0x0 14.--15. "  IP_1  ,Priority of interrupt 1" "0,1,2,3"
  bitfld.long 0x0 6.--7.   "  IP_0  ,Priority of interrupt 0" "0,1,2,3"

 line.long 0x4 "INT1,Interrupt Priority Register"
  bitfld.long 0x4 30.--31. " IP_7  ,Priority of interrupt 7" "0,1,2,3"
  bitfld.long 0x4 22.--23. "  IP_6  ,Priority of interrupt 6" "0,1,2,3"
  bitfld.long 0x4 14.--15. "  IP_5  ,Priority of interrupt 5" "0,1,2,3"
  bitfld.long 0x4 6.--7.   "  IP_4  ,Priority of interrupt 4" "0,1,2,3"

 line.long 0x8 "INT2,Interrupt Priority Register"
  bitfld.long 0x8 30.--31. " IP_11 ,Priority of interrupt 11" "0,1,2,3"
  bitfld.long 0x8 22.--23. "  IP_10 ,Priority of interrupt 10" "0,1,2,3"
  bitfld.long 0x8 14.--15. "  IP_9  ,Priority of interrupt 9" "0,1,2,3"
  bitfld.long 0x8 6.--7.   "  IP_8  ,Priority of interrupt 8" "0,1,2,3"

 line.long 0xC "INT3,Interrupt Priority Register"
  bitfld.long 0xC 30.--31. " IP_15 ,Priority of interrupt 15" "0,1,2,3"
  bitfld.long 0xC 22.--23. "  IP_14 ,Priority of interrupt 14" "0,1,2,3"
  bitfld.long 0xC 14.--15. "  IP_13 ,Priority of interrupt 13" "0,1,2,3"
  bitfld.long 0xC 6.--7.   "  IP_12 ,Priority of interrupt 12" "0,1,2,3"

 line.long 0x10 "INT4,Interrupt Priority Register"
  bitfld.long 0x10 30.--31. " IP_19 ,Priority of interrupt 19" "0,1,2,3"
  bitfld.long 0x10 22.--23. "  IP_18 ,Priority of interrupt 18" "0,1,2,3"
  bitfld.long 0x10 14.--15. "  IP_17 ,Priority of interrupt 17" "0,1,2,3"
  bitfld.long 0x10 6.--7.   "  IP_16 ,Priority of interrupt 16" "0,1,2,3"

 line.long 0x14 "INT5,Interrupt Priority Register"
  bitfld.long 0x14 30.--31. " IP_23 ,Priority of interrupt 23" "0,1,2,3"
  bitfld.long 0x14 22.--23. "  IP_22 ,Priority of interrupt 22" "0,1,2,3"
  bitfld.long 0x14 14.--15. "  IP_21 ,Priority of interrupt 21" "0,1,2,3"
  bitfld.long 0x14 6.--7.   "  IP_20 ,Priority of interrupt 20" "0,1,2,3"

 line.long 0x18 "INT6,Interrupt Priority Register"
  bitfld.long 0x18 30.--31. " IP_27 ,Priority of interrupt 27" "0,1,2,3"
  bitfld.long 0x18 22.--23. "  IP_26 ,Priority of interrupt 26" "0,1,2,3"
  bitfld.long 0x18 14.--15. "  IP_25 ,Priority of interrupt 25" "0,1,2,3"
  bitfld.long 0x18 6.--7.   "  IP_24 ,Priority of interrupt 24" "0,1,2,3"

 line.long 0x1C "INT7,Interrupt Priority Register"
  bitfld.long 0x1C 30.--31. " IP_31 ,Priority of interrupt 31" "0,1,2,3"
  bitfld.long 0x1C 22.--23. "  IP_30 ,Priority of interrupt 30" "0,1,2,3"
  bitfld.long 0x1C 14.--15. "  IP_29 ,Priority of interrupt 29" "0,1,2,3"
  bitfld.long 0x1C 6.--7.   "  IP_28 ,Priority of interrupt 28" "0,1,2,3"

width 7.  
  
  
  
  
  
tree.end  
tree.end 
 

tree "Debug Control"
 base d:0xe000ed00
width 0xa

group.long 0x30++0x03
  line.long 0x00 "DFSR,Data Fault Status Register"
   eventfld.long 0x00 4. " EXTERNAL          ,External debug request flag" "No occurred,Occurred"
   eventfld.long 0x00 3. "  VCATCH             ,Vector catch flag" "No occurred,Occurred"
  textline "                   "
   eventfld.long 0x00 2. " DWTRAP            ,Data Watchpoint flag" "No match,Match"
  textline "                   "
   eventfld.long 0x00 1. " BKPT              ,BKPT flag" "No match,Match"
   eventfld.long 0x00 0. "     HALTED             ,Halt request flag" "No request,Request"

if (((d.l(sd:0xf0))&0x01)==0x00)   
 group.long 0xf0++0x03
  line.long 0x00 "DHCSR,Debug Halting Control and Status Register"
   bitfld.long 0x00 31. " DBGKEY            ,Debug Key" "0,1"
   bitfld.long 0x00 30. "            DBGKEY             ,Debug Key" "0,1"
   textline "                   "
   bitfld.long 0x00 29. " DBGKEY            ,Debug Key" "0,1"
   bitfld.long 0x00 28. "            DBGKEY             ,Debug Key" "0,1"
   textline "                   "
   bitfld.long 0x00 27. " DBGKEY            ,Debug Key" "0,1"
   bitfld.long 0x00 26. "            DBGKEY             ,Debug Key" "0,1"
   textline "                   "
   bitfld.long 0x00 25. " S_RESET_ST/DBGKEY ,Core Reset/Debug Key" "No reset,Reset"
   bitfld.long 0x00 24. "     S_RETIRE_ST/DBGKEY ,Instruction completed since last read/Debug Key" "Not completed,Completed"
   textline "                   "
   bitfld.long 0x00 23. " DBGKEY            ,Debug Key" "0,1"
   bitfld.long 0x00 22. "            DBGKEY             ,Debug Key" "0,1"
   textline "                   "
   bitfld.long 0x00 21. " DBGKEY            ,Debug Key" "0,1"
   bitfld.long 0x00 20. "            DBGKEY             ,Debug Key" "0,1"
   textline "                   "
   bitfld.long 0x00 19. " DBGKEY            ,Debug Key" "0,1"
   bitfld.long 0x00 18. "            DBGKEY             ,Debug Key" "0,1"
   textline "                   "
   bitfld.long 0x00 17. " S_HALT/DBGKEY     ,Core Halted Status/Debug Key" "Not halted,Halted"
   bitfld.long 0x00 16. "   S_REGRDY/DBGKEY    ,Register R/W on the Debug Core Register Selector/Debug Key" "Not available,Available"
   textline "                   "
   bitfld.long 0x00 0. " C_DEBUGEN         ,Debug Enable" "Disabled,Enabled"
else 
 group.long 0xf0++0x03
  line.long 0x00 "DHCSR,Debug Halting Control and Status Register"
   bitfld.long 0x00 31. " DBGKEY            ,Debug Key" "0,1"
   bitfld.long 0x00 30. "            DBGKEY             ,Debug Key" "0,1"
   textline "                   "
   bitfld.long 0x00 29. " DBGKEY            ,Debug Key" "0,1"
   bitfld.long 0x00 28. "            DBGKEY             ,Debug Key" "0,1"
   textline "                   "
   bitfld.long 0x00 27. " DBGKEY            ,Debug Key" "0,1"
   bitfld.long 0x00 26. "            DBGKEY             ,Debug Key" "0,1"
   textline "                   "
   bitfld.long 0x00 25. " S_RESET_ST/DBGKEY ,Core Reset/Debug Key" "No reset,Reset"
   bitfld.long 0x00 24. "     S_RETIRE_ST/DBGKEY ,Instruction completed since last read/Debug Key" "Not read,Read"
   textline "                   "
   bitfld.long 0x00 23. " DBGKEY            ,Debug Key" "0,1"
   bitfld.long 0x00 22. "            DBGKEY             ,Debug Key" "0,1"
   textline "                   "
   bitfld.long 0x00 21. " DBGKEY            ,Debug Key" "0,1"
   bitfld.long 0x00 20. "            DBGKEY             ,Debug Key" "0,1"
   textline "                   "
   bitfld.long 0x00 19. " DBGKEY            ,Debug Key" "0,1"
   bitfld.long 0x00 18. "            DBGKEY             ,Debug Key" "0,1"
   textline "                   "
   bitfld.long 0x00 17. " S_HALT/DBGKEY     ,Core Halted Status/Debug Key" "Not halted,Halted"
   bitfld.long 0x00 16. "   S_REGRDY/DBGKEY    ,Register R/W on the Debug Core Register Selector/Debug Key" "Not available,Available"
   textline "                   "
   bitfld.long 0x00 3. " C_MASKINTS        ,Interrupts Mask" "Not masked,Masked"
   bitfld.long 0x00 2. "   C_STEP             ,Steps the core in halted debug" "Not halted,Halted"
   textline "                   "
   bitfld.long 0x00 1. " C_HALT            ,Core Halted" "Not halted,Halted"
   bitfld.long 0x00 0. "   C_DEBUGEN          ,Debug Enable" "Disabled,Enabled"
endif
  
wgroup.long 0xf4++0x03
 line.long 0x00 "DCRSR,Debug Core Selector Register"
   bitfld.long 0x00 16. " REGWnR            ,Register Read/Write" "Read,Write"
   bitfld.long 0x00 0.--4. "        REGSEL             ,Register Selection" "R0,R1,R2,R3,R4,R5,R6,R7,R8,R9,R10,R11,R12,Current SP,LR,DebugReturnAddress,xPSR Flags,MSP,PSP,Reserved,CONTROL[1]/PRIMASK[0],Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"

group.long 0xf8++0x07
 line.long 0x00 "DCRDR,Debug Core Register Data Register"
  hexmask.long 0x00 0.--31. 1 " DATA              ,Data for reading and writing registers to and from the processor"
 line.long 0x04 "DEMCR,Debug Exception and Monitor Control Register"
  bitfld.long 0x04 24. " DWTENA            ,Global enable or disable for the DW unit" "Disabled,Enabled"
  bitfld.long 0x04 10. "     VC_HARDERR         ,Debug trap on a Hard Fault" "No error,Error"
  textline "                   "
  bitfld.long 0x04 0.  " VC_CORERESET      ,Reset Vector Catch" "No reset,Reset" 
    
    
   
   
   
   
   
tree.end  

tree "ROM Table"
 base d:0xe00ff000
width 13.

group.long 0x00++0x0f
 line.long 0x00 "SCS,Points to the SCS at 0xE000E000" 
 line.long 0x04 "DW ,Points to the DW unit at 0xE0001000"  
 line.long 0x08 "BPU ,Points to the BPU at 0xE0002000"  
 line.long 0x0c "END ,Marks of end of table" 
rgroup.long 0xFCC++0x03
       line.long 0x00 "MEMTYPE,MemType Register"
       hexmask.long.byte 0x00 0.--7. 1 " PartNumber ,Part Number for Device [7:0]"
 
rgroup.long 0xFD0--0xFFF
    line.long 0x000 "PERIPHID4,Peripherial Identification Register 4"
       bitfld.long 0x000 4.--7. " 4KBCOUNT   ,Number of 4KB Block Used" "1,2,4,8,16,32,64,128,256,512,1024,2048,4096,8192,16384,32768"
       bitfld.long 0x000 0.--3. "                  JEP106CC   ,JEP106 Continuation Code" "0x0,0x1,0x2,0x3,0x4,0x5,0x6,0x7,0x8,0x9,0xA,0xB,0xC,0xD,0xE,0xF"
    line.long 0x004 "PERIPHID5,Peripherial Identification Register 5 (Reserved)"
    line.long 0x008 "PERIPHID6,Peripherial Identification Register 6 (Reserved)"
    line.long 0x00C "PERIPHID7,Peripherial Identification Register 7 (Reserved)"
    line.long 0x010 "PERIPHID0,Peripherial Identification Register 0"
       hexmask.long.byte 0x010 0.--7. 1 " PartNumber ,Part Number for Device [7:0]"
    line.long 0x014 "PERIPHID1,Peripherial Identification Register 1"
       bitfld.long 0x014 4.--7. " JEP106ID   ,JEP106 Identity Code [3:0]" "0x0,0x1,0x2,0x3,0x4,0x5,0x6,0x7,0x8,0x9,0xA,0xB,0xC,0xD,0xE,0xF"
       bitfld.long 0x014 0.--3. "                    PartNumber ,Part Number for Device [11:8]" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    line.long 0x018 "PERIPHID2,Peripherial Identification Register 2"
       bitfld.long 0x018 4.--7. " REV        ,Revision Number of Peripherial" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
       bitfld.long 0x018 3. "                     JEP106USED ,JEP106 Identity Code Used" "Not used,Used"
 textline "                      "
       bitfld.long 0x018 0.--2. " JEP106ID   ,JEP106 Identity Code [6:4]" "0x0,0x1,0x2,0x3,0x4,0x5,0x6,0x7"
    line.long 0x01C "PERIPHID3,Peripherial Identification Register 3"
       bitfld.long 0x01C 4.--7. " REVAND     ,Manufacturer Revision Number" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
       bitfld.long 0x01C 0.--3. "                     CM         ,Customer Modified" "0x0,0x1,0x2,0x3,0x4,0x5,0x6,0x7,0x8,0x9,0xA,0xB,0xC,0xD,0xE,0xF"

    line.long 0x020 "COMPONENT0,Component Identification Register 0"
       hexmask.long.byte 0x008 0.--7. 1 " PREAMBLE   ,Preamble"
    line.long 0x024 "COMPONENT1,Component Identification Register 1"
       bitfld.long 0x004 4.--7. " COMPCLASS  ,Component Class" "Generic verification,ROM table,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Debug interface,Reserved,PTB,Reserved,OptimoDE DESS,Generic IP,PrimeCell peripherial"
       bitfld.long 0x004 0.--3. "  PREAMBLE   ,Preamble" "0x0,0x1,0x2,0x3,0x4,0x5,0x6,0x7,0x8,0x9,0xA,0xB,0xC,0xD,0xE,0xF"
    line.long 0x028 "COMPONENT2,Component Identification Register 2"
       hexmask.long.byte 0x018 0.--7. 1 " PREAMBLE   ,Preamble"
    line.long 0x02C "COMPONENT3,Component Identification Register 3"
       hexmask.long.byte 0x01c 0.--7. 1 " PREAMBLE   ,Preamble"





tree.end  

tree "Breakpoint Unit"
 base d:0xe0002000
width 8.

group.long 0x00++0x03
 line.long 0x00 "BP_CTRL,Breakpoint Control Register"
  bitfld.long 0x00 4.--7. " NUM_CODE1 ,Number of comparators" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15" 
  bitfld.long 0x00 1.     "              KEY  ,Key field" "No write,Write"
  bitfld.long 0x00 0.     "  ENABLE ,Breakpoint unit enable bit" "Disabled,Enabled"
group.long 0x8++0x03 
 line.long 0x00 "B_COMP0,Breakpoint Comparator Registers 0"
  bitfld.long 0x00 30.--31. " BP_MATCH  ,Happens when the COMP address is matched" "No matching,Lower halfword,Upper halfword,Both halfwords"
  hexmask.long 0x00 2.--28. 2. "  COMP ,Comparison addres" 
  bitfld.long 0x00 0.     "  ENABLE ,Compare enable for Breakpoint Comparator Register 0" "Disabled,Enabled"

group.long 0xC++0x03 
 line.long 0x00 "B_COMP1,Breakpoint Comparator Registers 1"
  bitfld.long 0x00 30.--31. " BP_MATCH  ,Happens when the COMP address is matched" "No matching,Lower halfword,Upper halfword,Both halfwords"
  hexmask.long 0x00 2.--28. 2. "  COMP ,Comparison addres" 
  bitfld.long 0x00 0.     "  ENABLE ,Compare enable for Breakpoint Comparator Register 1" "Disabled,Enabled"

group.long 0x10++0x03 
 line.long 0x00 "B_COMP2,Breakpoint Comparator Registers 2"
  bitfld.long 0x00 30.--31. " BP_MATCH  ,Happens when the COMP address is matched" "No matching,Lower halfword,Upper halfword,Both halfwords"
  hexmask.long 0x00 2.--28. 2. "  COMP ,Comparison addres" 
  bitfld.long 0x00 0.     "  ENABLE ,Compare enable for Breakpoint Comparator Register 2" "Disabled,Enabled"

group.long 0x14++0x03 
 line.long 0x00 "B_COMP3,Breakpoint Comparator Registers 3"
  bitfld.long 0x00 30.--31. " BP_MATCH  ,Happens when the COMP address is matched" "No matching,Lower halfword,Upper halfword,Both halfwords"
  hexmask.long 0x00 2.--28. 2. "  COMP ,Comparison addres" 
  bitfld.long 0x00 0.     "  ENABLE ,Compare enable for Breakpoint Comparator Register 3" "Disabled,Enabled"

  
tree.end  

tree "Data Watchpoint"
 base d:0xe0001000
width 14.
rgroup.long 0x00++0x03
 line.long 0x00 "DW_CTRL,DW Control Register "
  bitfld.long 0x00 28.--31. " NUM_CODE1 ,Number of comparators" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
rgroup.long 0x1c++0x03
 line.long 0x00 "DW_PCSR,DW Program Counter Sample Register"
  hexmask.long 0x00 0.--31. 1. " EIASAMPLE ,Execution instruction address sample or 0xFFFFFFFF" 
group.long 0x20++0x0b
 line.long 0x00 "DW_COMP1,DW Comparator Register 1"
  hexmask.long 0x00 0.--31. 1. " COMP1     ,Compare against PC or the data address" 
 line.long 0x04 "DW_MASK1,DW Mask Register 1"
  hexmask.long.byte 0x04 0.--4. 1. " MASK      ,Mask on data address when matching against COMP" 
 line.long 0x08 "DW_FUNCTION1,DW Function Register 1"
  bitfld.long 0x08 24. " MATCHED   ,Comparator match" "No match,Match"
  bitfld.long 0x08 0.--3. "  FUNCTION , Settings for DW Function Registers" "Disabled,Reserved,Reserved,Reserved,On PC match,Read address,Write address,R/W address,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"
group.long 0x30++0x0b
 line.long 0x00 "DW_COMP2,DW Comparator Register 2"
  hexmask.long 0x00 0.--31. 1. " COMP      ,Compare against PC or the data address" 
 line.long 0x04 "DW_MASK2,DW Mask Register 2 "
  hexmask.long.byte 0x04 0.--4. 1. " MASK      ,Mask on data address when matching against COMP" 
 line.long 0x08 "DW_FUNCTION2,DW Function Register 2"
  bitfld.long 0x08 24. " MATCHED   ,Comparator match" "No match,Match"
  bitfld.long 0x08 0.--3. "  FUNCTION , Settings for DW Function Registers" "Disabled,Reserved,Reserved,Reserved,On PC match,Read address,Write address,R/W address,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved,Reserved"

  
  
  
  
  
  
  
  
  
  
  
  
  
  
tree.end  

tree "System Control"
 base d:0xe000e000
 
width 0x8 
group.long 0x10++0x0b
 line.long 0x00 "STCSR,SysTick Control and Status Register"
  bitfld.long 0x00 16. " COUNTFLAG    ,Returns 1 if timer counted to 0" "0,1"
  bitfld.long 0x00 2.  "              CLKSOURCE     ,Always reads as one" "No effect,Processor clock"
  textline "                 "
  bitfld.long 0x00 1.  " TICKINT      , Counting down to 0 " "No SysTick,SysTick"
  bitfld.long 0x00 0.  "     ENABLE        ,Counter enable" "Disabled,Enabled"
  
line.long 0x04 "STRVR,SysTick Reload Value Register"
  hexmask.long.tbyte 0x04 0.--23. 1. " RELOAD       ,Value to load into the STCVR when the counter reaches 0"

line.long 0x08 "STCVR,SysTick Current Value Register"
  hexmask.long.tbyte 0x08 0.--23. 1. " CURRENT      ,Reads return the current value of the SysTick counter"
  
rgroup.long 0x1c++0x03
line.long 0x00 "STCR,SysTick Calibration Value Register"
  bitfld.long 0x00 31. " NOREF        ,Reads as one" "0,1"
  bitfld.long 0x00 30. "              SKEW          ,Reads as zero" "0,1" 
  textline "                 "
  hexmask.long.tbyte 0x00 0.--23. 1. " TENMS        ,Indicates calibration value is not known"  
rgroup.long 0xd00++0x03
line.long 0x00 "CPUID,CPU ID Base Register"
  hexmask.long.byte 0x00 24.--31. 1. " IMPLEMENTER  ,Implementor code" 
  hexmask.long.byte 0x00 20.--23. 1. "             VARIANT       ,Implementation defined variant number" 
  textline "                 "
  hexmask.long.byte 0x00 4.--15. 1.  " PARTNO       ,Number of processor within family"
     hexmask.long.byte 0x00 0.--3. 1. "             REVISION      ,Implementation defined revision number" 

group.long 0xd04++0x03
 line.long 0x00 "ICSR,Interrupt Control State Register"
  bitfld.long 0x00 31. " NMIPENDSET   ,Setting this bit will activate an NMI" "No efect,Set pending"
  bitfld.long 0x00 28. "    PENDSVSET     ,Set a pending PendSV interrupt" "No efect,Set pending"
  textline "                 "
  bitfld.long 0x00 27. " PENDSVCLR    ,Clear a pending PendSV interrupt" "No efect,Clear pending"
  bitfld.long 0x00 26. "  PENDSTSET     ,Set a pending SysTick" "No efect,Set pending"
  textline "                 "
  bitfld.long 0x00 25. " PENDSVCLR    ,Clear a pending SysTick" "No efect,Clear pending"
  bitfld.long 0x00 23. "  ISRPREEMPT    ,Pending exception service" "No service,Service"
  textline "                 "
  bitfld.long 0x00 22. " ISRPENDING   ,External interrupt pending flag" "No interrupt,Interrupt"
  hexmask.long.byte 0x00 12.--17. 1. "   VECTPENDING   ,Active exception number field" 
  textline "                 "
  hexmask.long.byte 0x00 0.--5. 1.  " VECTACTIVET  ,Active exception number field" 
group.long 0xd0c++0x03  
 line.long 0x00 "AIRCR,Application Interrupt and Reset Control Register"  
  hexmask.long.word 0x00 16.--31. 1 " VECTKEY      ,Vector Key" 
  bitfld.long 0x00 15. "           ENDIANNESS    ,Data endianness bit" "Little-endian,Big-endian"
  textline "                 "
  bitfld.long 0x00 2. " SYSRESETREQ  ,System reset setup request" "No efect,Reset"
  bitfld.long 0x00 1. "       VECTCLRACTIVE ,Clears all active state information" "No clear,Clear"
group.long 0xd1c++0x0b
 line.long 0x00 "SHPR2,System Handler Priority Register 2"  
  bitfld.long 0x00 30.--31. " PRI_11       ,Priority of system handler 11-SVCall" "00,01,10,11" 
  
 line.long 0x04 "SHPR3,System Handler Priority Register 3"  
  bitfld.long 0x04 30.--31. " PRI_15       ,Priority of system handler 15-SysTick" "00,01,10,11"  
  bitfld.long 0x04 22.--23. "             PRI_14        ,Priority of system handler 14- PendSV" "00,01,10,11"  
  
 line.long 0x08 "SHCSR,System Handler Control and State Register"  
  bitfld.long 0x08 15. " SVCALLPENDED ,Reads as 1 if SVCall is pended" "Not pended,Pended" 
tree.end  

textline " "


